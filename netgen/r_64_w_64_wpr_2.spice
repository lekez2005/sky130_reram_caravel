*FIRST LINE IS A COMMENT

.SUBCKT reram_bitcell_7 bl br wl gnd
Xaccess be wl br gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=7.0 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625
Xmem bl be sky130_fd_pr__reram_reram_cell
.ENDS reram_bitcell_7
.subckt ms_flop_clk_buf din dout dout_bar clk vdd gnd
xm1 clk_buf clk_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 clk_buf clk_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 clk_bar clk gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm3 clk_bar clk vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 din clk_buf vdd gnd lout lout_bar clk_bar dlatch
x2 lout_bar clk_bar vdd gnd dout_bar dout clk_buf dlatch
.ends
.subckt dlatch  din clk vdd gnd dout dout_bar clk_bar
xm1 dout dout_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 dout_bar int gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 int clk dout gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 int clk_bar dout vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 int clk_bar din gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 int clk din vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout_bar int vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 dout dout_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

.SUBCKT flop_array_c128_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap din[0] din[1] din[2] din[3] din[4] din[5] din[6] din[7] din[8] din[9] din[10] din[11] din[12] din[13] din[14] din[15] din[16] din[17] din[18] din[19] din[20] din[21] din[22] din[23] din[24] din[25] din[26] din[27] din[28] din[29] din[30] din[31] din[32] din[33] din[34] din[35] din[36] din[37] din[38] din[39] din[40] din[41] din[42] din[43] din[44] din[45] din[46] din[47] din[48] din[49] din[50] din[51] din[52] din[53] din[54] din[55] din[56] din[57] din[58] din[59] din[60] din[61] din[62] din[63] dout[0] dout_bar[0] dout[1] dout_bar[1] dout[2] dout_bar[2] dout[3] dout_bar[3] dout[4] dout_bar[4] dout[5] dout_bar[5] dout[6] dout_bar[6] dout[7] dout_bar[7] dout[8] dout_bar[8] dout[9] dout_bar[9] dout[10] dout_bar[10] dout[11] dout_bar[11] dout[12] dout_bar[12] dout[13] dout_bar[13] dout[14] dout_bar[14] dout[15] dout_bar[15] dout[16] dout_bar[16] dout[17] dout_bar[17] dout[18] dout_bar[18] dout[19] dout_bar[19] dout[20] dout_bar[20] dout[21] dout_bar[21] dout[22] dout_bar[22] dout[23] dout_bar[23] dout[24] dout_bar[24] dout[25] dout_bar[25] dout[26] dout_bar[26] dout[27] dout_bar[27] dout[28] dout_bar[28] dout[29] dout_bar[29] dout[30] dout_bar[30] dout[31] dout_bar[31] dout[32] dout_bar[32] dout[33] dout_bar[33] dout[34] dout_bar[34] dout[35] dout_bar[35] dout[36] dout_bar[36] dout[37] dout_bar[37] dout[38] dout_bar[38] dout[39] dout_bar[39] dout[40] dout_bar[40] dout[41] dout_bar[41] dout[42] dout_bar[42] dout[43] dout_bar[43] dout[44] dout_bar[44] dout[45] dout_bar[45] dout[46] dout_bar[46] dout[47] dout_bar[47] dout[48] dout_bar[48] dout[49] dout_bar[49] dout[50] dout_bar[50] dout[51] dout_bar[51] dout[52] dout_bar[52] dout[53] dout_bar[53] dout[54] dout_bar[54] dout[55] dout_bar[55] dout[56] dout_bar[56] dout[57] dout_bar[57] dout[58] dout_bar[58] dout[59] dout_bar[59] dout[60] dout_bar[60] dout[61] dout_bar[61] dout[62] dout_bar[62] dout[63] dout_bar[63] clk vdd gnd
Xmod_0 din[0] dout[0] dout_bar[0] clk vdd gnd ms_flop_clk_buf
Xmod_1 din[1] dout[1] dout_bar[1] clk vdd gnd ms_flop_clk_buf
Xmod_2 din[2] dout[2] dout_bar[2] clk vdd gnd ms_flop_clk_buf
Xmod_3 din[3] dout[3] dout_bar[3] clk vdd gnd ms_flop_clk_buf
Xmod_4 din[4] dout[4] dout_bar[4] clk vdd gnd ms_flop_clk_buf
Xmod_5 din[5] dout[5] dout_bar[5] clk vdd gnd ms_flop_clk_buf
Xmod_6 din[6] dout[6] dout_bar[6] clk vdd gnd ms_flop_clk_buf
Xmod_7 din[7] dout[7] dout_bar[7] clk vdd gnd ms_flop_clk_buf
Xmod_8 din[8] dout[8] dout_bar[8] clk vdd gnd ms_flop_clk_buf
Xmod_9 din[9] dout[9] dout_bar[9] clk vdd gnd ms_flop_clk_buf
Xmod_10 din[10] dout[10] dout_bar[10] clk vdd gnd ms_flop_clk_buf
Xmod_11 din[11] dout[11] dout_bar[11] clk vdd gnd ms_flop_clk_buf
Xmod_12 din[12] dout[12] dout_bar[12] clk vdd gnd ms_flop_clk_buf
Xmod_13 din[13] dout[13] dout_bar[13] clk vdd gnd ms_flop_clk_buf
Xmod_14 din[14] dout[14] dout_bar[14] clk vdd gnd ms_flop_clk_buf
Xmod_15 din[15] dout[15] dout_bar[15] clk vdd gnd ms_flop_clk_buf
Xmod_16 din[16] dout[16] dout_bar[16] clk vdd gnd ms_flop_clk_buf
Xmod_17 din[17] dout[17] dout_bar[17] clk vdd gnd ms_flop_clk_buf
Xmod_18 din[18] dout[18] dout_bar[18] clk vdd gnd ms_flop_clk_buf
Xmod_19 din[19] dout[19] dout_bar[19] clk vdd gnd ms_flop_clk_buf
Xmod_20 din[20] dout[20] dout_bar[20] clk vdd gnd ms_flop_clk_buf
Xmod_21 din[21] dout[21] dout_bar[21] clk vdd gnd ms_flop_clk_buf
Xmod_22 din[22] dout[22] dout_bar[22] clk vdd gnd ms_flop_clk_buf
Xmod_23 din[23] dout[23] dout_bar[23] clk vdd gnd ms_flop_clk_buf
Xmod_24 din[24] dout[24] dout_bar[24] clk vdd gnd ms_flop_clk_buf
Xmod_25 din[25] dout[25] dout_bar[25] clk vdd gnd ms_flop_clk_buf
Xmod_26 din[26] dout[26] dout_bar[26] clk vdd gnd ms_flop_clk_buf
Xmod_27 din[27] dout[27] dout_bar[27] clk vdd gnd ms_flop_clk_buf
Xmod_28 din[28] dout[28] dout_bar[28] clk vdd gnd ms_flop_clk_buf
Xmod_29 din[29] dout[29] dout_bar[29] clk vdd gnd ms_flop_clk_buf
Xmod_30 din[30] dout[30] dout_bar[30] clk vdd gnd ms_flop_clk_buf
Xmod_31 din[31] dout[31] dout_bar[31] clk vdd gnd ms_flop_clk_buf
Xmod_32 din[32] dout[32] dout_bar[32] clk vdd gnd ms_flop_clk_buf
Xmod_33 din[33] dout[33] dout_bar[33] clk vdd gnd ms_flop_clk_buf
Xmod_34 din[34] dout[34] dout_bar[34] clk vdd gnd ms_flop_clk_buf
Xmod_35 din[35] dout[35] dout_bar[35] clk vdd gnd ms_flop_clk_buf
Xmod_36 din[36] dout[36] dout_bar[36] clk vdd gnd ms_flop_clk_buf
Xmod_37 din[37] dout[37] dout_bar[37] clk vdd gnd ms_flop_clk_buf
Xmod_38 din[38] dout[38] dout_bar[38] clk vdd gnd ms_flop_clk_buf
Xmod_39 din[39] dout[39] dout_bar[39] clk vdd gnd ms_flop_clk_buf
Xmod_40 din[40] dout[40] dout_bar[40] clk vdd gnd ms_flop_clk_buf
Xmod_41 din[41] dout[41] dout_bar[41] clk vdd gnd ms_flop_clk_buf
Xmod_42 din[42] dout[42] dout_bar[42] clk vdd gnd ms_flop_clk_buf
Xmod_43 din[43] dout[43] dout_bar[43] clk vdd gnd ms_flop_clk_buf
Xmod_44 din[44] dout[44] dout_bar[44] clk vdd gnd ms_flop_clk_buf
Xmod_45 din[45] dout[45] dout_bar[45] clk vdd gnd ms_flop_clk_buf
Xmod_46 din[46] dout[46] dout_bar[46] clk vdd gnd ms_flop_clk_buf
Xmod_47 din[47] dout[47] dout_bar[47] clk vdd gnd ms_flop_clk_buf
Xmod_48 din[48] dout[48] dout_bar[48] clk vdd gnd ms_flop_clk_buf
Xmod_49 din[49] dout[49] dout_bar[49] clk vdd gnd ms_flop_clk_buf
Xmod_50 din[50] dout[50] dout_bar[50] clk vdd gnd ms_flop_clk_buf
Xmod_51 din[51] dout[51] dout_bar[51] clk vdd gnd ms_flop_clk_buf
Xmod_52 din[52] dout[52] dout_bar[52] clk vdd gnd ms_flop_clk_buf
Xmod_53 din[53] dout[53] dout_bar[53] clk vdd gnd ms_flop_clk_buf
Xmod_54 din[54] dout[54] dout_bar[54] clk vdd gnd ms_flop_clk_buf
Xmod_55 din[55] dout[55] dout_bar[55] clk vdd gnd ms_flop_clk_buf
Xmod_56 din[56] dout[56] dout_bar[56] clk vdd gnd ms_flop_clk_buf
Xmod_57 din[57] dout[57] dout_bar[57] clk vdd gnd ms_flop_clk_buf
Xmod_58 din[58] dout[58] dout_bar[58] clk vdd gnd ms_flop_clk_buf
Xmod_59 din[59] dout[59] dout_bar[59] clk vdd gnd ms_flop_clk_buf
Xmod_60 din[60] dout[60] dout_bar[60] clk vdd gnd ms_flop_clk_buf
Xmod_61 din[61] dout[61] dout_bar[61] clk vdd gnd ms_flop_clk_buf
Xmod_62 din[62] dout[62] dout_bar[62] clk vdd gnd ms_flop_clk_buf
Xmod_63 din[63] dout[63] dout_bar[63] clk vdd gnd ms_flop_clk_buf
.ENDS flop_array_c128_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.16 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=8.1 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=4 w=8.64 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=21.6 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004

.SUBCKT write_driver_1__5_6 data data_bar mask_bar en en_bar bl br vdd gnd
XM0 gnd data bl_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM1 gnd mask_bar bl_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM2 gnd data_bar br_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM3 gnd mask_bar br_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM4 bl_bar data bl_log_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM5 bl_log_mid mask_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM6 br_bar data_bar br_log_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM7 br_log_mid mask_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM8 bl bl_bar bl_n_mid gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM9 bl_n_mid en gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM10 br br_bar br_n_mid gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM11 br_n_mid en gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM12 bl bl_bar bl_p_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
XM13 bl_p_mid en_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
XM14 br br_bar br_p_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
XM15 br_p_mid en_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
.ENDS write_driver_1__5_6

.SUBCKT write_driver_array data[0] data_bar[0] data[1] data_bar[1] data[2] data_bar[2] data[3] data_bar[3] data[4] data_bar[4] data[5] data_bar[5] data[6] data_bar[6] data[7] data_bar[7] data[8] data_bar[8] data[9] data_bar[9] data[10] data_bar[10] data[11] data_bar[11] data[12] data_bar[12] data[13] data_bar[13] data[14] data_bar[14] data[15] data_bar[15] data[16] data_bar[16] data[17] data_bar[17] data[18] data_bar[18] data[19] data_bar[19] data[20] data_bar[20] data[21] data_bar[21] data[22] data_bar[22] data[23] data_bar[23] data[24] data_bar[24] data[25] data_bar[25] data[26] data_bar[26] data[27] data_bar[27] data[28] data_bar[28] data[29] data_bar[29] data[30] data_bar[30] data[31] data_bar[31] data[32] data_bar[32] data[33] data_bar[33] data[34] data_bar[34] data[35] data_bar[35] data[36] data_bar[36] data[37] data_bar[37] data[38] data_bar[38] data[39] data_bar[39] data[40] data_bar[40] data[41] data_bar[41] data[42] data_bar[42] data[43] data_bar[43] data[44] data_bar[44] data[45] data_bar[45] data[46] data_bar[46] data[47] data_bar[47] data[48] data_bar[48] data[49] data_bar[49] data[50] data_bar[50] data[51] data_bar[51] data[52] data_bar[52] data[53] data_bar[53] data[54] data_bar[54] data[55] data_bar[55] data[56] data_bar[56] data[57] data_bar[57] data[58] data_bar[58] data[59] data_bar[59] data[60] data_bar[60] data[61] data_bar[61] data[62] data_bar[62] data[63] data_bar[63] bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] mask_bar[0] mask_bar[1] mask_bar[2] mask_bar[3] mask_bar[4] mask_bar[5] mask_bar[6] mask_bar[7] mask_bar[8] mask_bar[9] mask_bar[10] mask_bar[11] mask_bar[12] mask_bar[13] mask_bar[14] mask_bar[15] mask_bar[16] mask_bar[17] mask_bar[18] mask_bar[19] mask_bar[20] mask_bar[21] mask_bar[22] mask_bar[23] mask_bar[24] mask_bar[25] mask_bar[26] mask_bar[27] mask_bar[28] mask_bar[29] mask_bar[30] mask_bar[31] mask_bar[32] mask_bar[33] mask_bar[34] mask_bar[35] mask_bar[36] mask_bar[37] mask_bar[38] mask_bar[39] mask_bar[40] mask_bar[41] mask_bar[42] mask_bar[43] mask_bar[44] mask_bar[45] mask_bar[46] mask_bar[47] mask_bar[48] mask_bar[49] mask_bar[50] mask_bar[51] mask_bar[52] mask_bar[53] mask_bar[54] mask_bar[55] mask_bar[56] mask_bar[57] mask_bar[58] mask_bar[59] mask_bar[60] mask_bar[61] mask_bar[62] mask_bar[63] en en_bar vdd gnd
Xmod_0 data[0] data_bar[0] mask_bar[0] en en_bar bl[0] br[0] vdd gnd write_driver_1__5_6
Xmod_1 data[1] data_bar[1] mask_bar[1] en en_bar bl[1] br[1] vdd gnd write_driver_1__5_6
Xmod_2 data[2] data_bar[2] mask_bar[2] en en_bar bl[2] br[2] vdd gnd write_driver_1__5_6
Xmod_3 data[3] data_bar[3] mask_bar[3] en en_bar bl[3] br[3] vdd gnd write_driver_1__5_6
Xmod_4 data[4] data_bar[4] mask_bar[4] en en_bar bl[4] br[4] vdd gnd write_driver_1__5_6
Xmod_5 data[5] data_bar[5] mask_bar[5] en en_bar bl[5] br[5] vdd gnd write_driver_1__5_6
Xmod_6 data[6] data_bar[6] mask_bar[6] en en_bar bl[6] br[6] vdd gnd write_driver_1__5_6
Xmod_7 data[7] data_bar[7] mask_bar[7] en en_bar bl[7] br[7] vdd gnd write_driver_1__5_6
Xmod_8 data[8] data_bar[8] mask_bar[8] en en_bar bl[8] br[8] vdd gnd write_driver_1__5_6
Xmod_9 data[9] data_bar[9] mask_bar[9] en en_bar bl[9] br[9] vdd gnd write_driver_1__5_6
Xmod_10 data[10] data_bar[10] mask_bar[10] en en_bar bl[10] br[10] vdd gnd write_driver_1__5_6
Xmod_11 data[11] data_bar[11] mask_bar[11] en en_bar bl[11] br[11] vdd gnd write_driver_1__5_6
Xmod_12 data[12] data_bar[12] mask_bar[12] en en_bar bl[12] br[12] vdd gnd write_driver_1__5_6
Xmod_13 data[13] data_bar[13] mask_bar[13] en en_bar bl[13] br[13] vdd gnd write_driver_1__5_6
Xmod_14 data[14] data_bar[14] mask_bar[14] en en_bar bl[14] br[14] vdd gnd write_driver_1__5_6
Xmod_15 data[15] data_bar[15] mask_bar[15] en en_bar bl[15] br[15] vdd gnd write_driver_1__5_6
Xmod_16 data[16] data_bar[16] mask_bar[16] en en_bar bl[16] br[16] vdd gnd write_driver_1__5_6
Xmod_17 data[17] data_bar[17] mask_bar[17] en en_bar bl[17] br[17] vdd gnd write_driver_1__5_6
Xmod_18 data[18] data_bar[18] mask_bar[18] en en_bar bl[18] br[18] vdd gnd write_driver_1__5_6
Xmod_19 data[19] data_bar[19] mask_bar[19] en en_bar bl[19] br[19] vdd gnd write_driver_1__5_6
Xmod_20 data[20] data_bar[20] mask_bar[20] en en_bar bl[20] br[20] vdd gnd write_driver_1__5_6
Xmod_21 data[21] data_bar[21] mask_bar[21] en en_bar bl[21] br[21] vdd gnd write_driver_1__5_6
Xmod_22 data[22] data_bar[22] mask_bar[22] en en_bar bl[22] br[22] vdd gnd write_driver_1__5_6
Xmod_23 data[23] data_bar[23] mask_bar[23] en en_bar bl[23] br[23] vdd gnd write_driver_1__5_6
Xmod_24 data[24] data_bar[24] mask_bar[24] en en_bar bl[24] br[24] vdd gnd write_driver_1__5_6
Xmod_25 data[25] data_bar[25] mask_bar[25] en en_bar bl[25] br[25] vdd gnd write_driver_1__5_6
Xmod_26 data[26] data_bar[26] mask_bar[26] en en_bar bl[26] br[26] vdd gnd write_driver_1__5_6
Xmod_27 data[27] data_bar[27] mask_bar[27] en en_bar bl[27] br[27] vdd gnd write_driver_1__5_6
Xmod_28 data[28] data_bar[28] mask_bar[28] en en_bar bl[28] br[28] vdd gnd write_driver_1__5_6
Xmod_29 data[29] data_bar[29] mask_bar[29] en en_bar bl[29] br[29] vdd gnd write_driver_1__5_6
Xmod_30 data[30] data_bar[30] mask_bar[30] en en_bar bl[30] br[30] vdd gnd write_driver_1__5_6
Xmod_31 data[31] data_bar[31] mask_bar[31] en en_bar bl[31] br[31] vdd gnd write_driver_1__5_6
Xmod_32 data[32] data_bar[32] mask_bar[32] en en_bar bl[32] br[32] vdd gnd write_driver_1__5_6
Xmod_33 data[33] data_bar[33] mask_bar[33] en en_bar bl[33] br[33] vdd gnd write_driver_1__5_6
Xmod_34 data[34] data_bar[34] mask_bar[34] en en_bar bl[34] br[34] vdd gnd write_driver_1__5_6
Xmod_35 data[35] data_bar[35] mask_bar[35] en en_bar bl[35] br[35] vdd gnd write_driver_1__5_6
Xmod_36 data[36] data_bar[36] mask_bar[36] en en_bar bl[36] br[36] vdd gnd write_driver_1__5_6
Xmod_37 data[37] data_bar[37] mask_bar[37] en en_bar bl[37] br[37] vdd gnd write_driver_1__5_6
Xmod_38 data[38] data_bar[38] mask_bar[38] en en_bar bl[38] br[38] vdd gnd write_driver_1__5_6
Xmod_39 data[39] data_bar[39] mask_bar[39] en en_bar bl[39] br[39] vdd gnd write_driver_1__5_6
Xmod_40 data[40] data_bar[40] mask_bar[40] en en_bar bl[40] br[40] vdd gnd write_driver_1__5_6
Xmod_41 data[41] data_bar[41] mask_bar[41] en en_bar bl[41] br[41] vdd gnd write_driver_1__5_6
Xmod_42 data[42] data_bar[42] mask_bar[42] en en_bar bl[42] br[42] vdd gnd write_driver_1__5_6
Xmod_43 data[43] data_bar[43] mask_bar[43] en en_bar bl[43] br[43] vdd gnd write_driver_1__5_6
Xmod_44 data[44] data_bar[44] mask_bar[44] en en_bar bl[44] br[44] vdd gnd write_driver_1__5_6
Xmod_45 data[45] data_bar[45] mask_bar[45] en en_bar bl[45] br[45] vdd gnd write_driver_1__5_6
Xmod_46 data[46] data_bar[46] mask_bar[46] en en_bar bl[46] br[46] vdd gnd write_driver_1__5_6
Xmod_47 data[47] data_bar[47] mask_bar[47] en en_bar bl[47] br[47] vdd gnd write_driver_1__5_6
Xmod_48 data[48] data_bar[48] mask_bar[48] en en_bar bl[48] br[48] vdd gnd write_driver_1__5_6
Xmod_49 data[49] data_bar[49] mask_bar[49] en en_bar bl[49] br[49] vdd gnd write_driver_1__5_6
Xmod_50 data[50] data_bar[50] mask_bar[50] en en_bar bl[50] br[50] vdd gnd write_driver_1__5_6
Xmod_51 data[51] data_bar[51] mask_bar[51] en en_bar bl[51] br[51] vdd gnd write_driver_1__5_6
Xmod_52 data[52] data_bar[52] mask_bar[52] en en_bar bl[52] br[52] vdd gnd write_driver_1__5_6
Xmod_53 data[53] data_bar[53] mask_bar[53] en en_bar bl[53] br[53] vdd gnd write_driver_1__5_6
Xmod_54 data[54] data_bar[54] mask_bar[54] en en_bar bl[54] br[54] vdd gnd write_driver_1__5_6
Xmod_55 data[55] data_bar[55] mask_bar[55] en en_bar bl[55] br[55] vdd gnd write_driver_1__5_6
Xmod_56 data[56] data_bar[56] mask_bar[56] en en_bar bl[56] br[56] vdd gnd write_driver_1__5_6
Xmod_57 data[57] data_bar[57] mask_bar[57] en en_bar bl[57] br[57] vdd gnd write_driver_1__5_6
Xmod_58 data[58] data_bar[58] mask_bar[58] en en_bar bl[58] br[58] vdd gnd write_driver_1__5_6
Xmod_59 data[59] data_bar[59] mask_bar[59] en en_bar bl[59] br[59] vdd gnd write_driver_1__5_6
Xmod_60 data[60] data_bar[60] mask_bar[60] en en_bar bl[60] br[60] vdd gnd write_driver_1__5_6
Xmod_61 data[61] data_bar[61] mask_bar[61] en en_bar bl[61] br[61] vdd gnd write_driver_1__5_6
Xmod_62 data[62] data_bar[62] mask_bar[62] en en_bar bl[62] br[62] vdd gnd write_driver_1__5_6
Xmod_63 data[63] data_bar[63] mask_bar[63] en en_bar bl[63] br[63] vdd gnd write_driver_1__5_6
.ENDS write_driver_array

.SUBCKT bitcell_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] bl[64] br[64] bl[65] br[65] bl[66] br[66] bl[67] br[67] bl[68] br[68] bl[69] br[69] bl[70] br[70] bl[71] br[71] bl[72] br[72] bl[73] br[73] bl[74] br[74] bl[75] br[75] bl[76] br[76] bl[77] br[77] bl[78] br[78] bl[79] br[79] bl[80] br[80] bl[81] br[81] bl[82] br[82] bl[83] br[83] bl[84] br[84] bl[85] br[85] bl[86] br[86] bl[87] br[87] bl[88] br[88] bl[89] br[89] bl[90] br[90] bl[91] br[91] bl[92] br[92] bl[93] br[93] bl[94] br[94] bl[95] br[95] bl[96] br[96] bl[97] br[97] bl[98] br[98] bl[99] br[99] bl[100] br[100] bl[101] br[101] bl[102] br[102] bl[103] br[103] bl[104] br[104] bl[105] br[105] bl[106] br[106] bl[107] br[107] bl[108] br[108] bl[109] br[109] bl[110] br[110] bl[111] br[111] bl[112] br[112] bl[113] br[113] bl[114] br[114] bl[115] br[115] bl[116] br[116] bl[117] br[117] bl[118] br[118] bl[119] br[119] bl[120] br[120] bl[121] br[121] bl[122] br[122] bl[123] br[123] bl[124] br[124] bl[125] br[125] bl[126] br[126] bl[127] br[127] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] wl[32] wl[33] wl[34] wl[35] wl[36] wl[37] wl[38] wl[39] wl[40] wl[41] wl[42] wl[43] wl[44] wl[45] wl[46] wl[47] wl[48] wl[49] wl[50] wl[51] wl[52] wl[53] wl[54] wl[55] wl[56] wl[57] wl[58] wl[59] wl[60] wl[61] wl[62] wl[63] vdd gnd
Xbit_r0_c0 bl[0] br[0] wl[0] gnd reram_bitcell_7
Xbit_r1_c0 bl[0] br[0] wl[1] gnd reram_bitcell_7
Xbit_r2_c0 bl[0] br[0] wl[2] gnd reram_bitcell_7
Xbit_r3_c0 bl[0] br[0] wl[3] gnd reram_bitcell_7
Xbit_r4_c0 bl[0] br[0] wl[4] gnd reram_bitcell_7
Xbit_r5_c0 bl[0] br[0] wl[5] gnd reram_bitcell_7
Xbit_r6_c0 bl[0] br[0] wl[6] gnd reram_bitcell_7
Xbit_r7_c0 bl[0] br[0] wl[7] gnd reram_bitcell_7
Xbit_r8_c0 bl[0] br[0] wl[8] gnd reram_bitcell_7
Xbit_r9_c0 bl[0] br[0] wl[9] gnd reram_bitcell_7
Xbit_r10_c0 bl[0] br[0] wl[10] gnd reram_bitcell_7
Xbit_r11_c0 bl[0] br[0] wl[11] gnd reram_bitcell_7
Xbit_r12_c0 bl[0] br[0] wl[12] gnd reram_bitcell_7
Xbit_r13_c0 bl[0] br[0] wl[13] gnd reram_bitcell_7
Xbit_r14_c0 bl[0] br[0] wl[14] gnd reram_bitcell_7
Xbit_r15_c0 bl[0] br[0] wl[15] gnd reram_bitcell_7
Xbit_r16_c0 bl[0] br[0] wl[16] gnd reram_bitcell_7
Xbit_r17_c0 bl[0] br[0] wl[17] gnd reram_bitcell_7
Xbit_r18_c0 bl[0] br[0] wl[18] gnd reram_bitcell_7
Xbit_r19_c0 bl[0] br[0] wl[19] gnd reram_bitcell_7
Xbit_r20_c0 bl[0] br[0] wl[20] gnd reram_bitcell_7
Xbit_r21_c0 bl[0] br[0] wl[21] gnd reram_bitcell_7
Xbit_r22_c0 bl[0] br[0] wl[22] gnd reram_bitcell_7
Xbit_r23_c0 bl[0] br[0] wl[23] gnd reram_bitcell_7
Xbit_r24_c0 bl[0] br[0] wl[24] gnd reram_bitcell_7
Xbit_r25_c0 bl[0] br[0] wl[25] gnd reram_bitcell_7
Xbit_r26_c0 bl[0] br[0] wl[26] gnd reram_bitcell_7
Xbit_r27_c0 bl[0] br[0] wl[27] gnd reram_bitcell_7
Xbit_r28_c0 bl[0] br[0] wl[28] gnd reram_bitcell_7
Xbit_r29_c0 bl[0] br[0] wl[29] gnd reram_bitcell_7
Xbit_r30_c0 bl[0] br[0] wl[30] gnd reram_bitcell_7
Xbit_r31_c0 bl[0] br[0] wl[31] gnd reram_bitcell_7
Xbit_r32_c0 bl[0] br[0] wl[32] gnd reram_bitcell_7
Xbit_r33_c0 bl[0] br[0] wl[33] gnd reram_bitcell_7
Xbit_r34_c0 bl[0] br[0] wl[34] gnd reram_bitcell_7
Xbit_r35_c0 bl[0] br[0] wl[35] gnd reram_bitcell_7
Xbit_r36_c0 bl[0] br[0] wl[36] gnd reram_bitcell_7
Xbit_r37_c0 bl[0] br[0] wl[37] gnd reram_bitcell_7
Xbit_r38_c0 bl[0] br[0] wl[38] gnd reram_bitcell_7
Xbit_r39_c0 bl[0] br[0] wl[39] gnd reram_bitcell_7
Xbit_r40_c0 bl[0] br[0] wl[40] gnd reram_bitcell_7
Xbit_r41_c0 bl[0] br[0] wl[41] gnd reram_bitcell_7
Xbit_r42_c0 bl[0] br[0] wl[42] gnd reram_bitcell_7
Xbit_r43_c0 bl[0] br[0] wl[43] gnd reram_bitcell_7
Xbit_r44_c0 bl[0] br[0] wl[44] gnd reram_bitcell_7
Xbit_r45_c0 bl[0] br[0] wl[45] gnd reram_bitcell_7
Xbit_r46_c0 bl[0] br[0] wl[46] gnd reram_bitcell_7
Xbit_r47_c0 bl[0] br[0] wl[47] gnd reram_bitcell_7
Xbit_r48_c0 bl[0] br[0] wl[48] gnd reram_bitcell_7
Xbit_r49_c0 bl[0] br[0] wl[49] gnd reram_bitcell_7
Xbit_r50_c0 bl[0] br[0] wl[50] gnd reram_bitcell_7
Xbit_r51_c0 bl[0] br[0] wl[51] gnd reram_bitcell_7
Xbit_r52_c0 bl[0] br[0] wl[52] gnd reram_bitcell_7
Xbit_r53_c0 bl[0] br[0] wl[53] gnd reram_bitcell_7
Xbit_r54_c0 bl[0] br[0] wl[54] gnd reram_bitcell_7
Xbit_r55_c0 bl[0] br[0] wl[55] gnd reram_bitcell_7
Xbit_r56_c0 bl[0] br[0] wl[56] gnd reram_bitcell_7
Xbit_r57_c0 bl[0] br[0] wl[57] gnd reram_bitcell_7
Xbit_r58_c0 bl[0] br[0] wl[58] gnd reram_bitcell_7
Xbit_r59_c0 bl[0] br[0] wl[59] gnd reram_bitcell_7
Xbit_r60_c0 bl[0] br[0] wl[60] gnd reram_bitcell_7
Xbit_r61_c0 bl[0] br[0] wl[61] gnd reram_bitcell_7
Xbit_r62_c0 bl[0] br[0] wl[62] gnd reram_bitcell_7
Xbit_r63_c0 bl[0] br[0] wl[63] gnd reram_bitcell_7
Xbit_r0_c1 bl[1] br[1] wl[0] gnd reram_bitcell_7
Xbit_r1_c1 bl[1] br[1] wl[1] gnd reram_bitcell_7
Xbit_r2_c1 bl[1] br[1] wl[2] gnd reram_bitcell_7
Xbit_r3_c1 bl[1] br[1] wl[3] gnd reram_bitcell_7
Xbit_r4_c1 bl[1] br[1] wl[4] gnd reram_bitcell_7
Xbit_r5_c1 bl[1] br[1] wl[5] gnd reram_bitcell_7
Xbit_r6_c1 bl[1] br[1] wl[6] gnd reram_bitcell_7
Xbit_r7_c1 bl[1] br[1] wl[7] gnd reram_bitcell_7
Xbit_r8_c1 bl[1] br[1] wl[8] gnd reram_bitcell_7
Xbit_r9_c1 bl[1] br[1] wl[9] gnd reram_bitcell_7
Xbit_r10_c1 bl[1] br[1] wl[10] gnd reram_bitcell_7
Xbit_r11_c1 bl[1] br[1] wl[11] gnd reram_bitcell_7
Xbit_r12_c1 bl[1] br[1] wl[12] gnd reram_bitcell_7
Xbit_r13_c1 bl[1] br[1] wl[13] gnd reram_bitcell_7
Xbit_r14_c1 bl[1] br[1] wl[14] gnd reram_bitcell_7
Xbit_r15_c1 bl[1] br[1] wl[15] gnd reram_bitcell_7
Xbit_r16_c1 bl[1] br[1] wl[16] gnd reram_bitcell_7
Xbit_r17_c1 bl[1] br[1] wl[17] gnd reram_bitcell_7
Xbit_r18_c1 bl[1] br[1] wl[18] gnd reram_bitcell_7
Xbit_r19_c1 bl[1] br[1] wl[19] gnd reram_bitcell_7
Xbit_r20_c1 bl[1] br[1] wl[20] gnd reram_bitcell_7
Xbit_r21_c1 bl[1] br[1] wl[21] gnd reram_bitcell_7
Xbit_r22_c1 bl[1] br[1] wl[22] gnd reram_bitcell_7
Xbit_r23_c1 bl[1] br[1] wl[23] gnd reram_bitcell_7
Xbit_r24_c1 bl[1] br[1] wl[24] gnd reram_bitcell_7
Xbit_r25_c1 bl[1] br[1] wl[25] gnd reram_bitcell_7
Xbit_r26_c1 bl[1] br[1] wl[26] gnd reram_bitcell_7
Xbit_r27_c1 bl[1] br[1] wl[27] gnd reram_bitcell_7
Xbit_r28_c1 bl[1] br[1] wl[28] gnd reram_bitcell_7
Xbit_r29_c1 bl[1] br[1] wl[29] gnd reram_bitcell_7
Xbit_r30_c1 bl[1] br[1] wl[30] gnd reram_bitcell_7
Xbit_r31_c1 bl[1] br[1] wl[31] gnd reram_bitcell_7
Xbit_r32_c1 bl[1] br[1] wl[32] gnd reram_bitcell_7
Xbit_r33_c1 bl[1] br[1] wl[33] gnd reram_bitcell_7
Xbit_r34_c1 bl[1] br[1] wl[34] gnd reram_bitcell_7
Xbit_r35_c1 bl[1] br[1] wl[35] gnd reram_bitcell_7
Xbit_r36_c1 bl[1] br[1] wl[36] gnd reram_bitcell_7
Xbit_r37_c1 bl[1] br[1] wl[37] gnd reram_bitcell_7
Xbit_r38_c1 bl[1] br[1] wl[38] gnd reram_bitcell_7
Xbit_r39_c1 bl[1] br[1] wl[39] gnd reram_bitcell_7
Xbit_r40_c1 bl[1] br[1] wl[40] gnd reram_bitcell_7
Xbit_r41_c1 bl[1] br[1] wl[41] gnd reram_bitcell_7
Xbit_r42_c1 bl[1] br[1] wl[42] gnd reram_bitcell_7
Xbit_r43_c1 bl[1] br[1] wl[43] gnd reram_bitcell_7
Xbit_r44_c1 bl[1] br[1] wl[44] gnd reram_bitcell_7
Xbit_r45_c1 bl[1] br[1] wl[45] gnd reram_bitcell_7
Xbit_r46_c1 bl[1] br[1] wl[46] gnd reram_bitcell_7
Xbit_r47_c1 bl[1] br[1] wl[47] gnd reram_bitcell_7
Xbit_r48_c1 bl[1] br[1] wl[48] gnd reram_bitcell_7
Xbit_r49_c1 bl[1] br[1] wl[49] gnd reram_bitcell_7
Xbit_r50_c1 bl[1] br[1] wl[50] gnd reram_bitcell_7
Xbit_r51_c1 bl[1] br[1] wl[51] gnd reram_bitcell_7
Xbit_r52_c1 bl[1] br[1] wl[52] gnd reram_bitcell_7
Xbit_r53_c1 bl[1] br[1] wl[53] gnd reram_bitcell_7
Xbit_r54_c1 bl[1] br[1] wl[54] gnd reram_bitcell_7
Xbit_r55_c1 bl[1] br[1] wl[55] gnd reram_bitcell_7
Xbit_r56_c1 bl[1] br[1] wl[56] gnd reram_bitcell_7
Xbit_r57_c1 bl[1] br[1] wl[57] gnd reram_bitcell_7
Xbit_r58_c1 bl[1] br[1] wl[58] gnd reram_bitcell_7
Xbit_r59_c1 bl[1] br[1] wl[59] gnd reram_bitcell_7
Xbit_r60_c1 bl[1] br[1] wl[60] gnd reram_bitcell_7
Xbit_r61_c1 bl[1] br[1] wl[61] gnd reram_bitcell_7
Xbit_r62_c1 bl[1] br[1] wl[62] gnd reram_bitcell_7
Xbit_r63_c1 bl[1] br[1] wl[63] gnd reram_bitcell_7
Xbit_r0_c2 bl[2] br[2] wl[0] gnd reram_bitcell_7
Xbit_r1_c2 bl[2] br[2] wl[1] gnd reram_bitcell_7
Xbit_r2_c2 bl[2] br[2] wl[2] gnd reram_bitcell_7
Xbit_r3_c2 bl[2] br[2] wl[3] gnd reram_bitcell_7
Xbit_r4_c2 bl[2] br[2] wl[4] gnd reram_bitcell_7
Xbit_r5_c2 bl[2] br[2] wl[5] gnd reram_bitcell_7
Xbit_r6_c2 bl[2] br[2] wl[6] gnd reram_bitcell_7
Xbit_r7_c2 bl[2] br[2] wl[7] gnd reram_bitcell_7
Xbit_r8_c2 bl[2] br[2] wl[8] gnd reram_bitcell_7
Xbit_r9_c2 bl[2] br[2] wl[9] gnd reram_bitcell_7
Xbit_r10_c2 bl[2] br[2] wl[10] gnd reram_bitcell_7
Xbit_r11_c2 bl[2] br[2] wl[11] gnd reram_bitcell_7
Xbit_r12_c2 bl[2] br[2] wl[12] gnd reram_bitcell_7
Xbit_r13_c2 bl[2] br[2] wl[13] gnd reram_bitcell_7
Xbit_r14_c2 bl[2] br[2] wl[14] gnd reram_bitcell_7
Xbit_r15_c2 bl[2] br[2] wl[15] gnd reram_bitcell_7
Xbit_r16_c2 bl[2] br[2] wl[16] gnd reram_bitcell_7
Xbit_r17_c2 bl[2] br[2] wl[17] gnd reram_bitcell_7
Xbit_r18_c2 bl[2] br[2] wl[18] gnd reram_bitcell_7
Xbit_r19_c2 bl[2] br[2] wl[19] gnd reram_bitcell_7
Xbit_r20_c2 bl[2] br[2] wl[20] gnd reram_bitcell_7
Xbit_r21_c2 bl[2] br[2] wl[21] gnd reram_bitcell_7
Xbit_r22_c2 bl[2] br[2] wl[22] gnd reram_bitcell_7
Xbit_r23_c2 bl[2] br[2] wl[23] gnd reram_bitcell_7
Xbit_r24_c2 bl[2] br[2] wl[24] gnd reram_bitcell_7
Xbit_r25_c2 bl[2] br[2] wl[25] gnd reram_bitcell_7
Xbit_r26_c2 bl[2] br[2] wl[26] gnd reram_bitcell_7
Xbit_r27_c2 bl[2] br[2] wl[27] gnd reram_bitcell_7
Xbit_r28_c2 bl[2] br[2] wl[28] gnd reram_bitcell_7
Xbit_r29_c2 bl[2] br[2] wl[29] gnd reram_bitcell_7
Xbit_r30_c2 bl[2] br[2] wl[30] gnd reram_bitcell_7
Xbit_r31_c2 bl[2] br[2] wl[31] gnd reram_bitcell_7
Xbit_r32_c2 bl[2] br[2] wl[32] gnd reram_bitcell_7
Xbit_r33_c2 bl[2] br[2] wl[33] gnd reram_bitcell_7
Xbit_r34_c2 bl[2] br[2] wl[34] gnd reram_bitcell_7
Xbit_r35_c2 bl[2] br[2] wl[35] gnd reram_bitcell_7
Xbit_r36_c2 bl[2] br[2] wl[36] gnd reram_bitcell_7
Xbit_r37_c2 bl[2] br[2] wl[37] gnd reram_bitcell_7
Xbit_r38_c2 bl[2] br[2] wl[38] gnd reram_bitcell_7
Xbit_r39_c2 bl[2] br[2] wl[39] gnd reram_bitcell_7
Xbit_r40_c2 bl[2] br[2] wl[40] gnd reram_bitcell_7
Xbit_r41_c2 bl[2] br[2] wl[41] gnd reram_bitcell_7
Xbit_r42_c2 bl[2] br[2] wl[42] gnd reram_bitcell_7
Xbit_r43_c2 bl[2] br[2] wl[43] gnd reram_bitcell_7
Xbit_r44_c2 bl[2] br[2] wl[44] gnd reram_bitcell_7
Xbit_r45_c2 bl[2] br[2] wl[45] gnd reram_bitcell_7
Xbit_r46_c2 bl[2] br[2] wl[46] gnd reram_bitcell_7
Xbit_r47_c2 bl[2] br[2] wl[47] gnd reram_bitcell_7
Xbit_r48_c2 bl[2] br[2] wl[48] gnd reram_bitcell_7
Xbit_r49_c2 bl[2] br[2] wl[49] gnd reram_bitcell_7
Xbit_r50_c2 bl[2] br[2] wl[50] gnd reram_bitcell_7
Xbit_r51_c2 bl[2] br[2] wl[51] gnd reram_bitcell_7
Xbit_r52_c2 bl[2] br[2] wl[52] gnd reram_bitcell_7
Xbit_r53_c2 bl[2] br[2] wl[53] gnd reram_bitcell_7
Xbit_r54_c2 bl[2] br[2] wl[54] gnd reram_bitcell_7
Xbit_r55_c2 bl[2] br[2] wl[55] gnd reram_bitcell_7
Xbit_r56_c2 bl[2] br[2] wl[56] gnd reram_bitcell_7
Xbit_r57_c2 bl[2] br[2] wl[57] gnd reram_bitcell_7
Xbit_r58_c2 bl[2] br[2] wl[58] gnd reram_bitcell_7
Xbit_r59_c2 bl[2] br[2] wl[59] gnd reram_bitcell_7
Xbit_r60_c2 bl[2] br[2] wl[60] gnd reram_bitcell_7
Xbit_r61_c2 bl[2] br[2] wl[61] gnd reram_bitcell_7
Xbit_r62_c2 bl[2] br[2] wl[62] gnd reram_bitcell_7
Xbit_r63_c2 bl[2] br[2] wl[63] gnd reram_bitcell_7
Xbit_r0_c3 bl[3] br[3] wl[0] gnd reram_bitcell_7
Xbit_r1_c3 bl[3] br[3] wl[1] gnd reram_bitcell_7
Xbit_r2_c3 bl[3] br[3] wl[2] gnd reram_bitcell_7
Xbit_r3_c3 bl[3] br[3] wl[3] gnd reram_bitcell_7
Xbit_r4_c3 bl[3] br[3] wl[4] gnd reram_bitcell_7
Xbit_r5_c3 bl[3] br[3] wl[5] gnd reram_bitcell_7
Xbit_r6_c3 bl[3] br[3] wl[6] gnd reram_bitcell_7
Xbit_r7_c3 bl[3] br[3] wl[7] gnd reram_bitcell_7
Xbit_r8_c3 bl[3] br[3] wl[8] gnd reram_bitcell_7
Xbit_r9_c3 bl[3] br[3] wl[9] gnd reram_bitcell_7
Xbit_r10_c3 bl[3] br[3] wl[10] gnd reram_bitcell_7
Xbit_r11_c3 bl[3] br[3] wl[11] gnd reram_bitcell_7
Xbit_r12_c3 bl[3] br[3] wl[12] gnd reram_bitcell_7
Xbit_r13_c3 bl[3] br[3] wl[13] gnd reram_bitcell_7
Xbit_r14_c3 bl[3] br[3] wl[14] gnd reram_bitcell_7
Xbit_r15_c3 bl[3] br[3] wl[15] gnd reram_bitcell_7
Xbit_r16_c3 bl[3] br[3] wl[16] gnd reram_bitcell_7
Xbit_r17_c3 bl[3] br[3] wl[17] gnd reram_bitcell_7
Xbit_r18_c3 bl[3] br[3] wl[18] gnd reram_bitcell_7
Xbit_r19_c3 bl[3] br[3] wl[19] gnd reram_bitcell_7
Xbit_r20_c3 bl[3] br[3] wl[20] gnd reram_bitcell_7
Xbit_r21_c3 bl[3] br[3] wl[21] gnd reram_bitcell_7
Xbit_r22_c3 bl[3] br[3] wl[22] gnd reram_bitcell_7
Xbit_r23_c3 bl[3] br[3] wl[23] gnd reram_bitcell_7
Xbit_r24_c3 bl[3] br[3] wl[24] gnd reram_bitcell_7
Xbit_r25_c3 bl[3] br[3] wl[25] gnd reram_bitcell_7
Xbit_r26_c3 bl[3] br[3] wl[26] gnd reram_bitcell_7
Xbit_r27_c3 bl[3] br[3] wl[27] gnd reram_bitcell_7
Xbit_r28_c3 bl[3] br[3] wl[28] gnd reram_bitcell_7
Xbit_r29_c3 bl[3] br[3] wl[29] gnd reram_bitcell_7
Xbit_r30_c3 bl[3] br[3] wl[30] gnd reram_bitcell_7
Xbit_r31_c3 bl[3] br[3] wl[31] gnd reram_bitcell_7
Xbit_r32_c3 bl[3] br[3] wl[32] gnd reram_bitcell_7
Xbit_r33_c3 bl[3] br[3] wl[33] gnd reram_bitcell_7
Xbit_r34_c3 bl[3] br[3] wl[34] gnd reram_bitcell_7
Xbit_r35_c3 bl[3] br[3] wl[35] gnd reram_bitcell_7
Xbit_r36_c3 bl[3] br[3] wl[36] gnd reram_bitcell_7
Xbit_r37_c3 bl[3] br[3] wl[37] gnd reram_bitcell_7
Xbit_r38_c3 bl[3] br[3] wl[38] gnd reram_bitcell_7
Xbit_r39_c3 bl[3] br[3] wl[39] gnd reram_bitcell_7
Xbit_r40_c3 bl[3] br[3] wl[40] gnd reram_bitcell_7
Xbit_r41_c3 bl[3] br[3] wl[41] gnd reram_bitcell_7
Xbit_r42_c3 bl[3] br[3] wl[42] gnd reram_bitcell_7
Xbit_r43_c3 bl[3] br[3] wl[43] gnd reram_bitcell_7
Xbit_r44_c3 bl[3] br[3] wl[44] gnd reram_bitcell_7
Xbit_r45_c3 bl[3] br[3] wl[45] gnd reram_bitcell_7
Xbit_r46_c3 bl[3] br[3] wl[46] gnd reram_bitcell_7
Xbit_r47_c3 bl[3] br[3] wl[47] gnd reram_bitcell_7
Xbit_r48_c3 bl[3] br[3] wl[48] gnd reram_bitcell_7
Xbit_r49_c3 bl[3] br[3] wl[49] gnd reram_bitcell_7
Xbit_r50_c3 bl[3] br[3] wl[50] gnd reram_bitcell_7
Xbit_r51_c3 bl[3] br[3] wl[51] gnd reram_bitcell_7
Xbit_r52_c3 bl[3] br[3] wl[52] gnd reram_bitcell_7
Xbit_r53_c3 bl[3] br[3] wl[53] gnd reram_bitcell_7
Xbit_r54_c3 bl[3] br[3] wl[54] gnd reram_bitcell_7
Xbit_r55_c3 bl[3] br[3] wl[55] gnd reram_bitcell_7
Xbit_r56_c3 bl[3] br[3] wl[56] gnd reram_bitcell_7
Xbit_r57_c3 bl[3] br[3] wl[57] gnd reram_bitcell_7
Xbit_r58_c3 bl[3] br[3] wl[58] gnd reram_bitcell_7
Xbit_r59_c3 bl[3] br[3] wl[59] gnd reram_bitcell_7
Xbit_r60_c3 bl[3] br[3] wl[60] gnd reram_bitcell_7
Xbit_r61_c3 bl[3] br[3] wl[61] gnd reram_bitcell_7
Xbit_r62_c3 bl[3] br[3] wl[62] gnd reram_bitcell_7
Xbit_r63_c3 bl[3] br[3] wl[63] gnd reram_bitcell_7
Xbit_r0_c4 bl[4] br[4] wl[0] gnd reram_bitcell_7
Xbit_r1_c4 bl[4] br[4] wl[1] gnd reram_bitcell_7
Xbit_r2_c4 bl[4] br[4] wl[2] gnd reram_bitcell_7
Xbit_r3_c4 bl[4] br[4] wl[3] gnd reram_bitcell_7
Xbit_r4_c4 bl[4] br[4] wl[4] gnd reram_bitcell_7
Xbit_r5_c4 bl[4] br[4] wl[5] gnd reram_bitcell_7
Xbit_r6_c4 bl[4] br[4] wl[6] gnd reram_bitcell_7
Xbit_r7_c4 bl[4] br[4] wl[7] gnd reram_bitcell_7
Xbit_r8_c4 bl[4] br[4] wl[8] gnd reram_bitcell_7
Xbit_r9_c4 bl[4] br[4] wl[9] gnd reram_bitcell_7
Xbit_r10_c4 bl[4] br[4] wl[10] gnd reram_bitcell_7
Xbit_r11_c4 bl[4] br[4] wl[11] gnd reram_bitcell_7
Xbit_r12_c4 bl[4] br[4] wl[12] gnd reram_bitcell_7
Xbit_r13_c4 bl[4] br[4] wl[13] gnd reram_bitcell_7
Xbit_r14_c4 bl[4] br[4] wl[14] gnd reram_bitcell_7
Xbit_r15_c4 bl[4] br[4] wl[15] gnd reram_bitcell_7
Xbit_r16_c4 bl[4] br[4] wl[16] gnd reram_bitcell_7
Xbit_r17_c4 bl[4] br[4] wl[17] gnd reram_bitcell_7
Xbit_r18_c4 bl[4] br[4] wl[18] gnd reram_bitcell_7
Xbit_r19_c4 bl[4] br[4] wl[19] gnd reram_bitcell_7
Xbit_r20_c4 bl[4] br[4] wl[20] gnd reram_bitcell_7
Xbit_r21_c4 bl[4] br[4] wl[21] gnd reram_bitcell_7
Xbit_r22_c4 bl[4] br[4] wl[22] gnd reram_bitcell_7
Xbit_r23_c4 bl[4] br[4] wl[23] gnd reram_bitcell_7
Xbit_r24_c4 bl[4] br[4] wl[24] gnd reram_bitcell_7
Xbit_r25_c4 bl[4] br[4] wl[25] gnd reram_bitcell_7
Xbit_r26_c4 bl[4] br[4] wl[26] gnd reram_bitcell_7
Xbit_r27_c4 bl[4] br[4] wl[27] gnd reram_bitcell_7
Xbit_r28_c4 bl[4] br[4] wl[28] gnd reram_bitcell_7
Xbit_r29_c4 bl[4] br[4] wl[29] gnd reram_bitcell_7
Xbit_r30_c4 bl[4] br[4] wl[30] gnd reram_bitcell_7
Xbit_r31_c4 bl[4] br[4] wl[31] gnd reram_bitcell_7
Xbit_r32_c4 bl[4] br[4] wl[32] gnd reram_bitcell_7
Xbit_r33_c4 bl[4] br[4] wl[33] gnd reram_bitcell_7
Xbit_r34_c4 bl[4] br[4] wl[34] gnd reram_bitcell_7
Xbit_r35_c4 bl[4] br[4] wl[35] gnd reram_bitcell_7
Xbit_r36_c4 bl[4] br[4] wl[36] gnd reram_bitcell_7
Xbit_r37_c4 bl[4] br[4] wl[37] gnd reram_bitcell_7
Xbit_r38_c4 bl[4] br[4] wl[38] gnd reram_bitcell_7
Xbit_r39_c4 bl[4] br[4] wl[39] gnd reram_bitcell_7
Xbit_r40_c4 bl[4] br[4] wl[40] gnd reram_bitcell_7
Xbit_r41_c4 bl[4] br[4] wl[41] gnd reram_bitcell_7
Xbit_r42_c4 bl[4] br[4] wl[42] gnd reram_bitcell_7
Xbit_r43_c4 bl[4] br[4] wl[43] gnd reram_bitcell_7
Xbit_r44_c4 bl[4] br[4] wl[44] gnd reram_bitcell_7
Xbit_r45_c4 bl[4] br[4] wl[45] gnd reram_bitcell_7
Xbit_r46_c4 bl[4] br[4] wl[46] gnd reram_bitcell_7
Xbit_r47_c4 bl[4] br[4] wl[47] gnd reram_bitcell_7
Xbit_r48_c4 bl[4] br[4] wl[48] gnd reram_bitcell_7
Xbit_r49_c4 bl[4] br[4] wl[49] gnd reram_bitcell_7
Xbit_r50_c4 bl[4] br[4] wl[50] gnd reram_bitcell_7
Xbit_r51_c4 bl[4] br[4] wl[51] gnd reram_bitcell_7
Xbit_r52_c4 bl[4] br[4] wl[52] gnd reram_bitcell_7
Xbit_r53_c4 bl[4] br[4] wl[53] gnd reram_bitcell_7
Xbit_r54_c4 bl[4] br[4] wl[54] gnd reram_bitcell_7
Xbit_r55_c4 bl[4] br[4] wl[55] gnd reram_bitcell_7
Xbit_r56_c4 bl[4] br[4] wl[56] gnd reram_bitcell_7
Xbit_r57_c4 bl[4] br[4] wl[57] gnd reram_bitcell_7
Xbit_r58_c4 bl[4] br[4] wl[58] gnd reram_bitcell_7
Xbit_r59_c4 bl[4] br[4] wl[59] gnd reram_bitcell_7
Xbit_r60_c4 bl[4] br[4] wl[60] gnd reram_bitcell_7
Xbit_r61_c4 bl[4] br[4] wl[61] gnd reram_bitcell_7
Xbit_r62_c4 bl[4] br[4] wl[62] gnd reram_bitcell_7
Xbit_r63_c4 bl[4] br[4] wl[63] gnd reram_bitcell_7
Xbit_r0_c5 bl[5] br[5] wl[0] gnd reram_bitcell_7
Xbit_r1_c5 bl[5] br[5] wl[1] gnd reram_bitcell_7
Xbit_r2_c5 bl[5] br[5] wl[2] gnd reram_bitcell_7
Xbit_r3_c5 bl[5] br[5] wl[3] gnd reram_bitcell_7
Xbit_r4_c5 bl[5] br[5] wl[4] gnd reram_bitcell_7
Xbit_r5_c5 bl[5] br[5] wl[5] gnd reram_bitcell_7
Xbit_r6_c5 bl[5] br[5] wl[6] gnd reram_bitcell_7
Xbit_r7_c5 bl[5] br[5] wl[7] gnd reram_bitcell_7
Xbit_r8_c5 bl[5] br[5] wl[8] gnd reram_bitcell_7
Xbit_r9_c5 bl[5] br[5] wl[9] gnd reram_bitcell_7
Xbit_r10_c5 bl[5] br[5] wl[10] gnd reram_bitcell_7
Xbit_r11_c5 bl[5] br[5] wl[11] gnd reram_bitcell_7
Xbit_r12_c5 bl[5] br[5] wl[12] gnd reram_bitcell_7
Xbit_r13_c5 bl[5] br[5] wl[13] gnd reram_bitcell_7
Xbit_r14_c5 bl[5] br[5] wl[14] gnd reram_bitcell_7
Xbit_r15_c5 bl[5] br[5] wl[15] gnd reram_bitcell_7
Xbit_r16_c5 bl[5] br[5] wl[16] gnd reram_bitcell_7
Xbit_r17_c5 bl[5] br[5] wl[17] gnd reram_bitcell_7
Xbit_r18_c5 bl[5] br[5] wl[18] gnd reram_bitcell_7
Xbit_r19_c5 bl[5] br[5] wl[19] gnd reram_bitcell_7
Xbit_r20_c5 bl[5] br[5] wl[20] gnd reram_bitcell_7
Xbit_r21_c5 bl[5] br[5] wl[21] gnd reram_bitcell_7
Xbit_r22_c5 bl[5] br[5] wl[22] gnd reram_bitcell_7
Xbit_r23_c5 bl[5] br[5] wl[23] gnd reram_bitcell_7
Xbit_r24_c5 bl[5] br[5] wl[24] gnd reram_bitcell_7
Xbit_r25_c5 bl[5] br[5] wl[25] gnd reram_bitcell_7
Xbit_r26_c5 bl[5] br[5] wl[26] gnd reram_bitcell_7
Xbit_r27_c5 bl[5] br[5] wl[27] gnd reram_bitcell_7
Xbit_r28_c5 bl[5] br[5] wl[28] gnd reram_bitcell_7
Xbit_r29_c5 bl[5] br[5] wl[29] gnd reram_bitcell_7
Xbit_r30_c5 bl[5] br[5] wl[30] gnd reram_bitcell_7
Xbit_r31_c5 bl[5] br[5] wl[31] gnd reram_bitcell_7
Xbit_r32_c5 bl[5] br[5] wl[32] gnd reram_bitcell_7
Xbit_r33_c5 bl[5] br[5] wl[33] gnd reram_bitcell_7
Xbit_r34_c5 bl[5] br[5] wl[34] gnd reram_bitcell_7
Xbit_r35_c5 bl[5] br[5] wl[35] gnd reram_bitcell_7
Xbit_r36_c5 bl[5] br[5] wl[36] gnd reram_bitcell_7
Xbit_r37_c5 bl[5] br[5] wl[37] gnd reram_bitcell_7
Xbit_r38_c5 bl[5] br[5] wl[38] gnd reram_bitcell_7
Xbit_r39_c5 bl[5] br[5] wl[39] gnd reram_bitcell_7
Xbit_r40_c5 bl[5] br[5] wl[40] gnd reram_bitcell_7
Xbit_r41_c5 bl[5] br[5] wl[41] gnd reram_bitcell_7
Xbit_r42_c5 bl[5] br[5] wl[42] gnd reram_bitcell_7
Xbit_r43_c5 bl[5] br[5] wl[43] gnd reram_bitcell_7
Xbit_r44_c5 bl[5] br[5] wl[44] gnd reram_bitcell_7
Xbit_r45_c5 bl[5] br[5] wl[45] gnd reram_bitcell_7
Xbit_r46_c5 bl[5] br[5] wl[46] gnd reram_bitcell_7
Xbit_r47_c5 bl[5] br[5] wl[47] gnd reram_bitcell_7
Xbit_r48_c5 bl[5] br[5] wl[48] gnd reram_bitcell_7
Xbit_r49_c5 bl[5] br[5] wl[49] gnd reram_bitcell_7
Xbit_r50_c5 bl[5] br[5] wl[50] gnd reram_bitcell_7
Xbit_r51_c5 bl[5] br[5] wl[51] gnd reram_bitcell_7
Xbit_r52_c5 bl[5] br[5] wl[52] gnd reram_bitcell_7
Xbit_r53_c5 bl[5] br[5] wl[53] gnd reram_bitcell_7
Xbit_r54_c5 bl[5] br[5] wl[54] gnd reram_bitcell_7
Xbit_r55_c5 bl[5] br[5] wl[55] gnd reram_bitcell_7
Xbit_r56_c5 bl[5] br[5] wl[56] gnd reram_bitcell_7
Xbit_r57_c5 bl[5] br[5] wl[57] gnd reram_bitcell_7
Xbit_r58_c5 bl[5] br[5] wl[58] gnd reram_bitcell_7
Xbit_r59_c5 bl[5] br[5] wl[59] gnd reram_bitcell_7
Xbit_r60_c5 bl[5] br[5] wl[60] gnd reram_bitcell_7
Xbit_r61_c5 bl[5] br[5] wl[61] gnd reram_bitcell_7
Xbit_r62_c5 bl[5] br[5] wl[62] gnd reram_bitcell_7
Xbit_r63_c5 bl[5] br[5] wl[63] gnd reram_bitcell_7
Xbit_r0_c6 bl[6] br[6] wl[0] gnd reram_bitcell_7
Xbit_r1_c6 bl[6] br[6] wl[1] gnd reram_bitcell_7
Xbit_r2_c6 bl[6] br[6] wl[2] gnd reram_bitcell_7
Xbit_r3_c6 bl[6] br[6] wl[3] gnd reram_bitcell_7
Xbit_r4_c6 bl[6] br[6] wl[4] gnd reram_bitcell_7
Xbit_r5_c6 bl[6] br[6] wl[5] gnd reram_bitcell_7
Xbit_r6_c6 bl[6] br[6] wl[6] gnd reram_bitcell_7
Xbit_r7_c6 bl[6] br[6] wl[7] gnd reram_bitcell_7
Xbit_r8_c6 bl[6] br[6] wl[8] gnd reram_bitcell_7
Xbit_r9_c6 bl[6] br[6] wl[9] gnd reram_bitcell_7
Xbit_r10_c6 bl[6] br[6] wl[10] gnd reram_bitcell_7
Xbit_r11_c6 bl[6] br[6] wl[11] gnd reram_bitcell_7
Xbit_r12_c6 bl[6] br[6] wl[12] gnd reram_bitcell_7
Xbit_r13_c6 bl[6] br[6] wl[13] gnd reram_bitcell_7
Xbit_r14_c6 bl[6] br[6] wl[14] gnd reram_bitcell_7
Xbit_r15_c6 bl[6] br[6] wl[15] gnd reram_bitcell_7
Xbit_r16_c6 bl[6] br[6] wl[16] gnd reram_bitcell_7
Xbit_r17_c6 bl[6] br[6] wl[17] gnd reram_bitcell_7
Xbit_r18_c6 bl[6] br[6] wl[18] gnd reram_bitcell_7
Xbit_r19_c6 bl[6] br[6] wl[19] gnd reram_bitcell_7
Xbit_r20_c6 bl[6] br[6] wl[20] gnd reram_bitcell_7
Xbit_r21_c6 bl[6] br[6] wl[21] gnd reram_bitcell_7
Xbit_r22_c6 bl[6] br[6] wl[22] gnd reram_bitcell_7
Xbit_r23_c6 bl[6] br[6] wl[23] gnd reram_bitcell_7
Xbit_r24_c6 bl[6] br[6] wl[24] gnd reram_bitcell_7
Xbit_r25_c6 bl[6] br[6] wl[25] gnd reram_bitcell_7
Xbit_r26_c6 bl[6] br[6] wl[26] gnd reram_bitcell_7
Xbit_r27_c6 bl[6] br[6] wl[27] gnd reram_bitcell_7
Xbit_r28_c6 bl[6] br[6] wl[28] gnd reram_bitcell_7
Xbit_r29_c6 bl[6] br[6] wl[29] gnd reram_bitcell_7
Xbit_r30_c6 bl[6] br[6] wl[30] gnd reram_bitcell_7
Xbit_r31_c6 bl[6] br[6] wl[31] gnd reram_bitcell_7
Xbit_r32_c6 bl[6] br[6] wl[32] gnd reram_bitcell_7
Xbit_r33_c6 bl[6] br[6] wl[33] gnd reram_bitcell_7
Xbit_r34_c6 bl[6] br[6] wl[34] gnd reram_bitcell_7
Xbit_r35_c6 bl[6] br[6] wl[35] gnd reram_bitcell_7
Xbit_r36_c6 bl[6] br[6] wl[36] gnd reram_bitcell_7
Xbit_r37_c6 bl[6] br[6] wl[37] gnd reram_bitcell_7
Xbit_r38_c6 bl[6] br[6] wl[38] gnd reram_bitcell_7
Xbit_r39_c6 bl[6] br[6] wl[39] gnd reram_bitcell_7
Xbit_r40_c6 bl[6] br[6] wl[40] gnd reram_bitcell_7
Xbit_r41_c6 bl[6] br[6] wl[41] gnd reram_bitcell_7
Xbit_r42_c6 bl[6] br[6] wl[42] gnd reram_bitcell_7
Xbit_r43_c6 bl[6] br[6] wl[43] gnd reram_bitcell_7
Xbit_r44_c6 bl[6] br[6] wl[44] gnd reram_bitcell_7
Xbit_r45_c6 bl[6] br[6] wl[45] gnd reram_bitcell_7
Xbit_r46_c6 bl[6] br[6] wl[46] gnd reram_bitcell_7
Xbit_r47_c6 bl[6] br[6] wl[47] gnd reram_bitcell_7
Xbit_r48_c6 bl[6] br[6] wl[48] gnd reram_bitcell_7
Xbit_r49_c6 bl[6] br[6] wl[49] gnd reram_bitcell_7
Xbit_r50_c6 bl[6] br[6] wl[50] gnd reram_bitcell_7
Xbit_r51_c6 bl[6] br[6] wl[51] gnd reram_bitcell_7
Xbit_r52_c6 bl[6] br[6] wl[52] gnd reram_bitcell_7
Xbit_r53_c6 bl[6] br[6] wl[53] gnd reram_bitcell_7
Xbit_r54_c6 bl[6] br[6] wl[54] gnd reram_bitcell_7
Xbit_r55_c6 bl[6] br[6] wl[55] gnd reram_bitcell_7
Xbit_r56_c6 bl[6] br[6] wl[56] gnd reram_bitcell_7
Xbit_r57_c6 bl[6] br[6] wl[57] gnd reram_bitcell_7
Xbit_r58_c6 bl[6] br[6] wl[58] gnd reram_bitcell_7
Xbit_r59_c6 bl[6] br[6] wl[59] gnd reram_bitcell_7
Xbit_r60_c6 bl[6] br[6] wl[60] gnd reram_bitcell_7
Xbit_r61_c6 bl[6] br[6] wl[61] gnd reram_bitcell_7
Xbit_r62_c6 bl[6] br[6] wl[62] gnd reram_bitcell_7
Xbit_r63_c6 bl[6] br[6] wl[63] gnd reram_bitcell_7
Xbit_r0_c7 bl[7] br[7] wl[0] gnd reram_bitcell_7
Xbit_r1_c7 bl[7] br[7] wl[1] gnd reram_bitcell_7
Xbit_r2_c7 bl[7] br[7] wl[2] gnd reram_bitcell_7
Xbit_r3_c7 bl[7] br[7] wl[3] gnd reram_bitcell_7
Xbit_r4_c7 bl[7] br[7] wl[4] gnd reram_bitcell_7
Xbit_r5_c7 bl[7] br[7] wl[5] gnd reram_bitcell_7
Xbit_r6_c7 bl[7] br[7] wl[6] gnd reram_bitcell_7
Xbit_r7_c7 bl[7] br[7] wl[7] gnd reram_bitcell_7
Xbit_r8_c7 bl[7] br[7] wl[8] gnd reram_bitcell_7
Xbit_r9_c7 bl[7] br[7] wl[9] gnd reram_bitcell_7
Xbit_r10_c7 bl[7] br[7] wl[10] gnd reram_bitcell_7
Xbit_r11_c7 bl[7] br[7] wl[11] gnd reram_bitcell_7
Xbit_r12_c7 bl[7] br[7] wl[12] gnd reram_bitcell_7
Xbit_r13_c7 bl[7] br[7] wl[13] gnd reram_bitcell_7
Xbit_r14_c7 bl[7] br[7] wl[14] gnd reram_bitcell_7
Xbit_r15_c7 bl[7] br[7] wl[15] gnd reram_bitcell_7
Xbit_r16_c7 bl[7] br[7] wl[16] gnd reram_bitcell_7
Xbit_r17_c7 bl[7] br[7] wl[17] gnd reram_bitcell_7
Xbit_r18_c7 bl[7] br[7] wl[18] gnd reram_bitcell_7
Xbit_r19_c7 bl[7] br[7] wl[19] gnd reram_bitcell_7
Xbit_r20_c7 bl[7] br[7] wl[20] gnd reram_bitcell_7
Xbit_r21_c7 bl[7] br[7] wl[21] gnd reram_bitcell_7
Xbit_r22_c7 bl[7] br[7] wl[22] gnd reram_bitcell_7
Xbit_r23_c7 bl[7] br[7] wl[23] gnd reram_bitcell_7
Xbit_r24_c7 bl[7] br[7] wl[24] gnd reram_bitcell_7
Xbit_r25_c7 bl[7] br[7] wl[25] gnd reram_bitcell_7
Xbit_r26_c7 bl[7] br[7] wl[26] gnd reram_bitcell_7
Xbit_r27_c7 bl[7] br[7] wl[27] gnd reram_bitcell_7
Xbit_r28_c7 bl[7] br[7] wl[28] gnd reram_bitcell_7
Xbit_r29_c7 bl[7] br[7] wl[29] gnd reram_bitcell_7
Xbit_r30_c7 bl[7] br[7] wl[30] gnd reram_bitcell_7
Xbit_r31_c7 bl[7] br[7] wl[31] gnd reram_bitcell_7
Xbit_r32_c7 bl[7] br[7] wl[32] gnd reram_bitcell_7
Xbit_r33_c7 bl[7] br[7] wl[33] gnd reram_bitcell_7
Xbit_r34_c7 bl[7] br[7] wl[34] gnd reram_bitcell_7
Xbit_r35_c7 bl[7] br[7] wl[35] gnd reram_bitcell_7
Xbit_r36_c7 bl[7] br[7] wl[36] gnd reram_bitcell_7
Xbit_r37_c7 bl[7] br[7] wl[37] gnd reram_bitcell_7
Xbit_r38_c7 bl[7] br[7] wl[38] gnd reram_bitcell_7
Xbit_r39_c7 bl[7] br[7] wl[39] gnd reram_bitcell_7
Xbit_r40_c7 bl[7] br[7] wl[40] gnd reram_bitcell_7
Xbit_r41_c7 bl[7] br[7] wl[41] gnd reram_bitcell_7
Xbit_r42_c7 bl[7] br[7] wl[42] gnd reram_bitcell_7
Xbit_r43_c7 bl[7] br[7] wl[43] gnd reram_bitcell_7
Xbit_r44_c7 bl[7] br[7] wl[44] gnd reram_bitcell_7
Xbit_r45_c7 bl[7] br[7] wl[45] gnd reram_bitcell_7
Xbit_r46_c7 bl[7] br[7] wl[46] gnd reram_bitcell_7
Xbit_r47_c7 bl[7] br[7] wl[47] gnd reram_bitcell_7
Xbit_r48_c7 bl[7] br[7] wl[48] gnd reram_bitcell_7
Xbit_r49_c7 bl[7] br[7] wl[49] gnd reram_bitcell_7
Xbit_r50_c7 bl[7] br[7] wl[50] gnd reram_bitcell_7
Xbit_r51_c7 bl[7] br[7] wl[51] gnd reram_bitcell_7
Xbit_r52_c7 bl[7] br[7] wl[52] gnd reram_bitcell_7
Xbit_r53_c7 bl[7] br[7] wl[53] gnd reram_bitcell_7
Xbit_r54_c7 bl[7] br[7] wl[54] gnd reram_bitcell_7
Xbit_r55_c7 bl[7] br[7] wl[55] gnd reram_bitcell_7
Xbit_r56_c7 bl[7] br[7] wl[56] gnd reram_bitcell_7
Xbit_r57_c7 bl[7] br[7] wl[57] gnd reram_bitcell_7
Xbit_r58_c7 bl[7] br[7] wl[58] gnd reram_bitcell_7
Xbit_r59_c7 bl[7] br[7] wl[59] gnd reram_bitcell_7
Xbit_r60_c7 bl[7] br[7] wl[60] gnd reram_bitcell_7
Xbit_r61_c7 bl[7] br[7] wl[61] gnd reram_bitcell_7
Xbit_r62_c7 bl[7] br[7] wl[62] gnd reram_bitcell_7
Xbit_r63_c7 bl[7] br[7] wl[63] gnd reram_bitcell_7
Xbit_r0_c8 bl[8] br[8] wl[0] gnd reram_bitcell_7
Xbit_r1_c8 bl[8] br[8] wl[1] gnd reram_bitcell_7
Xbit_r2_c8 bl[8] br[8] wl[2] gnd reram_bitcell_7
Xbit_r3_c8 bl[8] br[8] wl[3] gnd reram_bitcell_7
Xbit_r4_c8 bl[8] br[8] wl[4] gnd reram_bitcell_7
Xbit_r5_c8 bl[8] br[8] wl[5] gnd reram_bitcell_7
Xbit_r6_c8 bl[8] br[8] wl[6] gnd reram_bitcell_7
Xbit_r7_c8 bl[8] br[8] wl[7] gnd reram_bitcell_7
Xbit_r8_c8 bl[8] br[8] wl[8] gnd reram_bitcell_7
Xbit_r9_c8 bl[8] br[8] wl[9] gnd reram_bitcell_7
Xbit_r10_c8 bl[8] br[8] wl[10] gnd reram_bitcell_7
Xbit_r11_c8 bl[8] br[8] wl[11] gnd reram_bitcell_7
Xbit_r12_c8 bl[8] br[8] wl[12] gnd reram_bitcell_7
Xbit_r13_c8 bl[8] br[8] wl[13] gnd reram_bitcell_7
Xbit_r14_c8 bl[8] br[8] wl[14] gnd reram_bitcell_7
Xbit_r15_c8 bl[8] br[8] wl[15] gnd reram_bitcell_7
Xbit_r16_c8 bl[8] br[8] wl[16] gnd reram_bitcell_7
Xbit_r17_c8 bl[8] br[8] wl[17] gnd reram_bitcell_7
Xbit_r18_c8 bl[8] br[8] wl[18] gnd reram_bitcell_7
Xbit_r19_c8 bl[8] br[8] wl[19] gnd reram_bitcell_7
Xbit_r20_c8 bl[8] br[8] wl[20] gnd reram_bitcell_7
Xbit_r21_c8 bl[8] br[8] wl[21] gnd reram_bitcell_7
Xbit_r22_c8 bl[8] br[8] wl[22] gnd reram_bitcell_7
Xbit_r23_c8 bl[8] br[8] wl[23] gnd reram_bitcell_7
Xbit_r24_c8 bl[8] br[8] wl[24] gnd reram_bitcell_7
Xbit_r25_c8 bl[8] br[8] wl[25] gnd reram_bitcell_7
Xbit_r26_c8 bl[8] br[8] wl[26] gnd reram_bitcell_7
Xbit_r27_c8 bl[8] br[8] wl[27] gnd reram_bitcell_7
Xbit_r28_c8 bl[8] br[8] wl[28] gnd reram_bitcell_7
Xbit_r29_c8 bl[8] br[8] wl[29] gnd reram_bitcell_7
Xbit_r30_c8 bl[8] br[8] wl[30] gnd reram_bitcell_7
Xbit_r31_c8 bl[8] br[8] wl[31] gnd reram_bitcell_7
Xbit_r32_c8 bl[8] br[8] wl[32] gnd reram_bitcell_7
Xbit_r33_c8 bl[8] br[8] wl[33] gnd reram_bitcell_7
Xbit_r34_c8 bl[8] br[8] wl[34] gnd reram_bitcell_7
Xbit_r35_c8 bl[8] br[8] wl[35] gnd reram_bitcell_7
Xbit_r36_c8 bl[8] br[8] wl[36] gnd reram_bitcell_7
Xbit_r37_c8 bl[8] br[8] wl[37] gnd reram_bitcell_7
Xbit_r38_c8 bl[8] br[8] wl[38] gnd reram_bitcell_7
Xbit_r39_c8 bl[8] br[8] wl[39] gnd reram_bitcell_7
Xbit_r40_c8 bl[8] br[8] wl[40] gnd reram_bitcell_7
Xbit_r41_c8 bl[8] br[8] wl[41] gnd reram_bitcell_7
Xbit_r42_c8 bl[8] br[8] wl[42] gnd reram_bitcell_7
Xbit_r43_c8 bl[8] br[8] wl[43] gnd reram_bitcell_7
Xbit_r44_c8 bl[8] br[8] wl[44] gnd reram_bitcell_7
Xbit_r45_c8 bl[8] br[8] wl[45] gnd reram_bitcell_7
Xbit_r46_c8 bl[8] br[8] wl[46] gnd reram_bitcell_7
Xbit_r47_c8 bl[8] br[8] wl[47] gnd reram_bitcell_7
Xbit_r48_c8 bl[8] br[8] wl[48] gnd reram_bitcell_7
Xbit_r49_c8 bl[8] br[8] wl[49] gnd reram_bitcell_7
Xbit_r50_c8 bl[8] br[8] wl[50] gnd reram_bitcell_7
Xbit_r51_c8 bl[8] br[8] wl[51] gnd reram_bitcell_7
Xbit_r52_c8 bl[8] br[8] wl[52] gnd reram_bitcell_7
Xbit_r53_c8 bl[8] br[8] wl[53] gnd reram_bitcell_7
Xbit_r54_c8 bl[8] br[8] wl[54] gnd reram_bitcell_7
Xbit_r55_c8 bl[8] br[8] wl[55] gnd reram_bitcell_7
Xbit_r56_c8 bl[8] br[8] wl[56] gnd reram_bitcell_7
Xbit_r57_c8 bl[8] br[8] wl[57] gnd reram_bitcell_7
Xbit_r58_c8 bl[8] br[8] wl[58] gnd reram_bitcell_7
Xbit_r59_c8 bl[8] br[8] wl[59] gnd reram_bitcell_7
Xbit_r60_c8 bl[8] br[8] wl[60] gnd reram_bitcell_7
Xbit_r61_c8 bl[8] br[8] wl[61] gnd reram_bitcell_7
Xbit_r62_c8 bl[8] br[8] wl[62] gnd reram_bitcell_7
Xbit_r63_c8 bl[8] br[8] wl[63] gnd reram_bitcell_7
Xbit_r0_c9 bl[9] br[9] wl[0] gnd reram_bitcell_7
Xbit_r1_c9 bl[9] br[9] wl[1] gnd reram_bitcell_7
Xbit_r2_c9 bl[9] br[9] wl[2] gnd reram_bitcell_7
Xbit_r3_c9 bl[9] br[9] wl[3] gnd reram_bitcell_7
Xbit_r4_c9 bl[9] br[9] wl[4] gnd reram_bitcell_7
Xbit_r5_c9 bl[9] br[9] wl[5] gnd reram_bitcell_7
Xbit_r6_c9 bl[9] br[9] wl[6] gnd reram_bitcell_7
Xbit_r7_c9 bl[9] br[9] wl[7] gnd reram_bitcell_7
Xbit_r8_c9 bl[9] br[9] wl[8] gnd reram_bitcell_7
Xbit_r9_c9 bl[9] br[9] wl[9] gnd reram_bitcell_7
Xbit_r10_c9 bl[9] br[9] wl[10] gnd reram_bitcell_7
Xbit_r11_c9 bl[9] br[9] wl[11] gnd reram_bitcell_7
Xbit_r12_c9 bl[9] br[9] wl[12] gnd reram_bitcell_7
Xbit_r13_c9 bl[9] br[9] wl[13] gnd reram_bitcell_7
Xbit_r14_c9 bl[9] br[9] wl[14] gnd reram_bitcell_7
Xbit_r15_c9 bl[9] br[9] wl[15] gnd reram_bitcell_7
Xbit_r16_c9 bl[9] br[9] wl[16] gnd reram_bitcell_7
Xbit_r17_c9 bl[9] br[9] wl[17] gnd reram_bitcell_7
Xbit_r18_c9 bl[9] br[9] wl[18] gnd reram_bitcell_7
Xbit_r19_c9 bl[9] br[9] wl[19] gnd reram_bitcell_7
Xbit_r20_c9 bl[9] br[9] wl[20] gnd reram_bitcell_7
Xbit_r21_c9 bl[9] br[9] wl[21] gnd reram_bitcell_7
Xbit_r22_c9 bl[9] br[9] wl[22] gnd reram_bitcell_7
Xbit_r23_c9 bl[9] br[9] wl[23] gnd reram_bitcell_7
Xbit_r24_c9 bl[9] br[9] wl[24] gnd reram_bitcell_7
Xbit_r25_c9 bl[9] br[9] wl[25] gnd reram_bitcell_7
Xbit_r26_c9 bl[9] br[9] wl[26] gnd reram_bitcell_7
Xbit_r27_c9 bl[9] br[9] wl[27] gnd reram_bitcell_7
Xbit_r28_c9 bl[9] br[9] wl[28] gnd reram_bitcell_7
Xbit_r29_c9 bl[9] br[9] wl[29] gnd reram_bitcell_7
Xbit_r30_c9 bl[9] br[9] wl[30] gnd reram_bitcell_7
Xbit_r31_c9 bl[9] br[9] wl[31] gnd reram_bitcell_7
Xbit_r32_c9 bl[9] br[9] wl[32] gnd reram_bitcell_7
Xbit_r33_c9 bl[9] br[9] wl[33] gnd reram_bitcell_7
Xbit_r34_c9 bl[9] br[9] wl[34] gnd reram_bitcell_7
Xbit_r35_c9 bl[9] br[9] wl[35] gnd reram_bitcell_7
Xbit_r36_c9 bl[9] br[9] wl[36] gnd reram_bitcell_7
Xbit_r37_c9 bl[9] br[9] wl[37] gnd reram_bitcell_7
Xbit_r38_c9 bl[9] br[9] wl[38] gnd reram_bitcell_7
Xbit_r39_c9 bl[9] br[9] wl[39] gnd reram_bitcell_7
Xbit_r40_c9 bl[9] br[9] wl[40] gnd reram_bitcell_7
Xbit_r41_c9 bl[9] br[9] wl[41] gnd reram_bitcell_7
Xbit_r42_c9 bl[9] br[9] wl[42] gnd reram_bitcell_7
Xbit_r43_c9 bl[9] br[9] wl[43] gnd reram_bitcell_7
Xbit_r44_c9 bl[9] br[9] wl[44] gnd reram_bitcell_7
Xbit_r45_c9 bl[9] br[9] wl[45] gnd reram_bitcell_7
Xbit_r46_c9 bl[9] br[9] wl[46] gnd reram_bitcell_7
Xbit_r47_c9 bl[9] br[9] wl[47] gnd reram_bitcell_7
Xbit_r48_c9 bl[9] br[9] wl[48] gnd reram_bitcell_7
Xbit_r49_c9 bl[9] br[9] wl[49] gnd reram_bitcell_7
Xbit_r50_c9 bl[9] br[9] wl[50] gnd reram_bitcell_7
Xbit_r51_c9 bl[9] br[9] wl[51] gnd reram_bitcell_7
Xbit_r52_c9 bl[9] br[9] wl[52] gnd reram_bitcell_7
Xbit_r53_c9 bl[9] br[9] wl[53] gnd reram_bitcell_7
Xbit_r54_c9 bl[9] br[9] wl[54] gnd reram_bitcell_7
Xbit_r55_c9 bl[9] br[9] wl[55] gnd reram_bitcell_7
Xbit_r56_c9 bl[9] br[9] wl[56] gnd reram_bitcell_7
Xbit_r57_c9 bl[9] br[9] wl[57] gnd reram_bitcell_7
Xbit_r58_c9 bl[9] br[9] wl[58] gnd reram_bitcell_7
Xbit_r59_c9 bl[9] br[9] wl[59] gnd reram_bitcell_7
Xbit_r60_c9 bl[9] br[9] wl[60] gnd reram_bitcell_7
Xbit_r61_c9 bl[9] br[9] wl[61] gnd reram_bitcell_7
Xbit_r62_c9 bl[9] br[9] wl[62] gnd reram_bitcell_7
Xbit_r63_c9 bl[9] br[9] wl[63] gnd reram_bitcell_7
Xbit_r0_c10 bl[10] br[10] wl[0] gnd reram_bitcell_7
Xbit_r1_c10 bl[10] br[10] wl[1] gnd reram_bitcell_7
Xbit_r2_c10 bl[10] br[10] wl[2] gnd reram_bitcell_7
Xbit_r3_c10 bl[10] br[10] wl[3] gnd reram_bitcell_7
Xbit_r4_c10 bl[10] br[10] wl[4] gnd reram_bitcell_7
Xbit_r5_c10 bl[10] br[10] wl[5] gnd reram_bitcell_7
Xbit_r6_c10 bl[10] br[10] wl[6] gnd reram_bitcell_7
Xbit_r7_c10 bl[10] br[10] wl[7] gnd reram_bitcell_7
Xbit_r8_c10 bl[10] br[10] wl[8] gnd reram_bitcell_7
Xbit_r9_c10 bl[10] br[10] wl[9] gnd reram_bitcell_7
Xbit_r10_c10 bl[10] br[10] wl[10] gnd reram_bitcell_7
Xbit_r11_c10 bl[10] br[10] wl[11] gnd reram_bitcell_7
Xbit_r12_c10 bl[10] br[10] wl[12] gnd reram_bitcell_7
Xbit_r13_c10 bl[10] br[10] wl[13] gnd reram_bitcell_7
Xbit_r14_c10 bl[10] br[10] wl[14] gnd reram_bitcell_7
Xbit_r15_c10 bl[10] br[10] wl[15] gnd reram_bitcell_7
Xbit_r16_c10 bl[10] br[10] wl[16] gnd reram_bitcell_7
Xbit_r17_c10 bl[10] br[10] wl[17] gnd reram_bitcell_7
Xbit_r18_c10 bl[10] br[10] wl[18] gnd reram_bitcell_7
Xbit_r19_c10 bl[10] br[10] wl[19] gnd reram_bitcell_7
Xbit_r20_c10 bl[10] br[10] wl[20] gnd reram_bitcell_7
Xbit_r21_c10 bl[10] br[10] wl[21] gnd reram_bitcell_7
Xbit_r22_c10 bl[10] br[10] wl[22] gnd reram_bitcell_7
Xbit_r23_c10 bl[10] br[10] wl[23] gnd reram_bitcell_7
Xbit_r24_c10 bl[10] br[10] wl[24] gnd reram_bitcell_7
Xbit_r25_c10 bl[10] br[10] wl[25] gnd reram_bitcell_7
Xbit_r26_c10 bl[10] br[10] wl[26] gnd reram_bitcell_7
Xbit_r27_c10 bl[10] br[10] wl[27] gnd reram_bitcell_7
Xbit_r28_c10 bl[10] br[10] wl[28] gnd reram_bitcell_7
Xbit_r29_c10 bl[10] br[10] wl[29] gnd reram_bitcell_7
Xbit_r30_c10 bl[10] br[10] wl[30] gnd reram_bitcell_7
Xbit_r31_c10 bl[10] br[10] wl[31] gnd reram_bitcell_7
Xbit_r32_c10 bl[10] br[10] wl[32] gnd reram_bitcell_7
Xbit_r33_c10 bl[10] br[10] wl[33] gnd reram_bitcell_7
Xbit_r34_c10 bl[10] br[10] wl[34] gnd reram_bitcell_7
Xbit_r35_c10 bl[10] br[10] wl[35] gnd reram_bitcell_7
Xbit_r36_c10 bl[10] br[10] wl[36] gnd reram_bitcell_7
Xbit_r37_c10 bl[10] br[10] wl[37] gnd reram_bitcell_7
Xbit_r38_c10 bl[10] br[10] wl[38] gnd reram_bitcell_7
Xbit_r39_c10 bl[10] br[10] wl[39] gnd reram_bitcell_7
Xbit_r40_c10 bl[10] br[10] wl[40] gnd reram_bitcell_7
Xbit_r41_c10 bl[10] br[10] wl[41] gnd reram_bitcell_7
Xbit_r42_c10 bl[10] br[10] wl[42] gnd reram_bitcell_7
Xbit_r43_c10 bl[10] br[10] wl[43] gnd reram_bitcell_7
Xbit_r44_c10 bl[10] br[10] wl[44] gnd reram_bitcell_7
Xbit_r45_c10 bl[10] br[10] wl[45] gnd reram_bitcell_7
Xbit_r46_c10 bl[10] br[10] wl[46] gnd reram_bitcell_7
Xbit_r47_c10 bl[10] br[10] wl[47] gnd reram_bitcell_7
Xbit_r48_c10 bl[10] br[10] wl[48] gnd reram_bitcell_7
Xbit_r49_c10 bl[10] br[10] wl[49] gnd reram_bitcell_7
Xbit_r50_c10 bl[10] br[10] wl[50] gnd reram_bitcell_7
Xbit_r51_c10 bl[10] br[10] wl[51] gnd reram_bitcell_7
Xbit_r52_c10 bl[10] br[10] wl[52] gnd reram_bitcell_7
Xbit_r53_c10 bl[10] br[10] wl[53] gnd reram_bitcell_7
Xbit_r54_c10 bl[10] br[10] wl[54] gnd reram_bitcell_7
Xbit_r55_c10 bl[10] br[10] wl[55] gnd reram_bitcell_7
Xbit_r56_c10 bl[10] br[10] wl[56] gnd reram_bitcell_7
Xbit_r57_c10 bl[10] br[10] wl[57] gnd reram_bitcell_7
Xbit_r58_c10 bl[10] br[10] wl[58] gnd reram_bitcell_7
Xbit_r59_c10 bl[10] br[10] wl[59] gnd reram_bitcell_7
Xbit_r60_c10 bl[10] br[10] wl[60] gnd reram_bitcell_7
Xbit_r61_c10 bl[10] br[10] wl[61] gnd reram_bitcell_7
Xbit_r62_c10 bl[10] br[10] wl[62] gnd reram_bitcell_7
Xbit_r63_c10 bl[10] br[10] wl[63] gnd reram_bitcell_7
Xbit_r0_c11 bl[11] br[11] wl[0] gnd reram_bitcell_7
Xbit_r1_c11 bl[11] br[11] wl[1] gnd reram_bitcell_7
Xbit_r2_c11 bl[11] br[11] wl[2] gnd reram_bitcell_7
Xbit_r3_c11 bl[11] br[11] wl[3] gnd reram_bitcell_7
Xbit_r4_c11 bl[11] br[11] wl[4] gnd reram_bitcell_7
Xbit_r5_c11 bl[11] br[11] wl[5] gnd reram_bitcell_7
Xbit_r6_c11 bl[11] br[11] wl[6] gnd reram_bitcell_7
Xbit_r7_c11 bl[11] br[11] wl[7] gnd reram_bitcell_7
Xbit_r8_c11 bl[11] br[11] wl[8] gnd reram_bitcell_7
Xbit_r9_c11 bl[11] br[11] wl[9] gnd reram_bitcell_7
Xbit_r10_c11 bl[11] br[11] wl[10] gnd reram_bitcell_7
Xbit_r11_c11 bl[11] br[11] wl[11] gnd reram_bitcell_7
Xbit_r12_c11 bl[11] br[11] wl[12] gnd reram_bitcell_7
Xbit_r13_c11 bl[11] br[11] wl[13] gnd reram_bitcell_7
Xbit_r14_c11 bl[11] br[11] wl[14] gnd reram_bitcell_7
Xbit_r15_c11 bl[11] br[11] wl[15] gnd reram_bitcell_7
Xbit_r16_c11 bl[11] br[11] wl[16] gnd reram_bitcell_7
Xbit_r17_c11 bl[11] br[11] wl[17] gnd reram_bitcell_7
Xbit_r18_c11 bl[11] br[11] wl[18] gnd reram_bitcell_7
Xbit_r19_c11 bl[11] br[11] wl[19] gnd reram_bitcell_7
Xbit_r20_c11 bl[11] br[11] wl[20] gnd reram_bitcell_7
Xbit_r21_c11 bl[11] br[11] wl[21] gnd reram_bitcell_7
Xbit_r22_c11 bl[11] br[11] wl[22] gnd reram_bitcell_7
Xbit_r23_c11 bl[11] br[11] wl[23] gnd reram_bitcell_7
Xbit_r24_c11 bl[11] br[11] wl[24] gnd reram_bitcell_7
Xbit_r25_c11 bl[11] br[11] wl[25] gnd reram_bitcell_7
Xbit_r26_c11 bl[11] br[11] wl[26] gnd reram_bitcell_7
Xbit_r27_c11 bl[11] br[11] wl[27] gnd reram_bitcell_7
Xbit_r28_c11 bl[11] br[11] wl[28] gnd reram_bitcell_7
Xbit_r29_c11 bl[11] br[11] wl[29] gnd reram_bitcell_7
Xbit_r30_c11 bl[11] br[11] wl[30] gnd reram_bitcell_7
Xbit_r31_c11 bl[11] br[11] wl[31] gnd reram_bitcell_7
Xbit_r32_c11 bl[11] br[11] wl[32] gnd reram_bitcell_7
Xbit_r33_c11 bl[11] br[11] wl[33] gnd reram_bitcell_7
Xbit_r34_c11 bl[11] br[11] wl[34] gnd reram_bitcell_7
Xbit_r35_c11 bl[11] br[11] wl[35] gnd reram_bitcell_7
Xbit_r36_c11 bl[11] br[11] wl[36] gnd reram_bitcell_7
Xbit_r37_c11 bl[11] br[11] wl[37] gnd reram_bitcell_7
Xbit_r38_c11 bl[11] br[11] wl[38] gnd reram_bitcell_7
Xbit_r39_c11 bl[11] br[11] wl[39] gnd reram_bitcell_7
Xbit_r40_c11 bl[11] br[11] wl[40] gnd reram_bitcell_7
Xbit_r41_c11 bl[11] br[11] wl[41] gnd reram_bitcell_7
Xbit_r42_c11 bl[11] br[11] wl[42] gnd reram_bitcell_7
Xbit_r43_c11 bl[11] br[11] wl[43] gnd reram_bitcell_7
Xbit_r44_c11 bl[11] br[11] wl[44] gnd reram_bitcell_7
Xbit_r45_c11 bl[11] br[11] wl[45] gnd reram_bitcell_7
Xbit_r46_c11 bl[11] br[11] wl[46] gnd reram_bitcell_7
Xbit_r47_c11 bl[11] br[11] wl[47] gnd reram_bitcell_7
Xbit_r48_c11 bl[11] br[11] wl[48] gnd reram_bitcell_7
Xbit_r49_c11 bl[11] br[11] wl[49] gnd reram_bitcell_7
Xbit_r50_c11 bl[11] br[11] wl[50] gnd reram_bitcell_7
Xbit_r51_c11 bl[11] br[11] wl[51] gnd reram_bitcell_7
Xbit_r52_c11 bl[11] br[11] wl[52] gnd reram_bitcell_7
Xbit_r53_c11 bl[11] br[11] wl[53] gnd reram_bitcell_7
Xbit_r54_c11 bl[11] br[11] wl[54] gnd reram_bitcell_7
Xbit_r55_c11 bl[11] br[11] wl[55] gnd reram_bitcell_7
Xbit_r56_c11 bl[11] br[11] wl[56] gnd reram_bitcell_7
Xbit_r57_c11 bl[11] br[11] wl[57] gnd reram_bitcell_7
Xbit_r58_c11 bl[11] br[11] wl[58] gnd reram_bitcell_7
Xbit_r59_c11 bl[11] br[11] wl[59] gnd reram_bitcell_7
Xbit_r60_c11 bl[11] br[11] wl[60] gnd reram_bitcell_7
Xbit_r61_c11 bl[11] br[11] wl[61] gnd reram_bitcell_7
Xbit_r62_c11 bl[11] br[11] wl[62] gnd reram_bitcell_7
Xbit_r63_c11 bl[11] br[11] wl[63] gnd reram_bitcell_7
Xbit_r0_c12 bl[12] br[12] wl[0] gnd reram_bitcell_7
Xbit_r1_c12 bl[12] br[12] wl[1] gnd reram_bitcell_7
Xbit_r2_c12 bl[12] br[12] wl[2] gnd reram_bitcell_7
Xbit_r3_c12 bl[12] br[12] wl[3] gnd reram_bitcell_7
Xbit_r4_c12 bl[12] br[12] wl[4] gnd reram_bitcell_7
Xbit_r5_c12 bl[12] br[12] wl[5] gnd reram_bitcell_7
Xbit_r6_c12 bl[12] br[12] wl[6] gnd reram_bitcell_7
Xbit_r7_c12 bl[12] br[12] wl[7] gnd reram_bitcell_7
Xbit_r8_c12 bl[12] br[12] wl[8] gnd reram_bitcell_7
Xbit_r9_c12 bl[12] br[12] wl[9] gnd reram_bitcell_7
Xbit_r10_c12 bl[12] br[12] wl[10] gnd reram_bitcell_7
Xbit_r11_c12 bl[12] br[12] wl[11] gnd reram_bitcell_7
Xbit_r12_c12 bl[12] br[12] wl[12] gnd reram_bitcell_7
Xbit_r13_c12 bl[12] br[12] wl[13] gnd reram_bitcell_7
Xbit_r14_c12 bl[12] br[12] wl[14] gnd reram_bitcell_7
Xbit_r15_c12 bl[12] br[12] wl[15] gnd reram_bitcell_7
Xbit_r16_c12 bl[12] br[12] wl[16] gnd reram_bitcell_7
Xbit_r17_c12 bl[12] br[12] wl[17] gnd reram_bitcell_7
Xbit_r18_c12 bl[12] br[12] wl[18] gnd reram_bitcell_7
Xbit_r19_c12 bl[12] br[12] wl[19] gnd reram_bitcell_7
Xbit_r20_c12 bl[12] br[12] wl[20] gnd reram_bitcell_7
Xbit_r21_c12 bl[12] br[12] wl[21] gnd reram_bitcell_7
Xbit_r22_c12 bl[12] br[12] wl[22] gnd reram_bitcell_7
Xbit_r23_c12 bl[12] br[12] wl[23] gnd reram_bitcell_7
Xbit_r24_c12 bl[12] br[12] wl[24] gnd reram_bitcell_7
Xbit_r25_c12 bl[12] br[12] wl[25] gnd reram_bitcell_7
Xbit_r26_c12 bl[12] br[12] wl[26] gnd reram_bitcell_7
Xbit_r27_c12 bl[12] br[12] wl[27] gnd reram_bitcell_7
Xbit_r28_c12 bl[12] br[12] wl[28] gnd reram_bitcell_7
Xbit_r29_c12 bl[12] br[12] wl[29] gnd reram_bitcell_7
Xbit_r30_c12 bl[12] br[12] wl[30] gnd reram_bitcell_7
Xbit_r31_c12 bl[12] br[12] wl[31] gnd reram_bitcell_7
Xbit_r32_c12 bl[12] br[12] wl[32] gnd reram_bitcell_7
Xbit_r33_c12 bl[12] br[12] wl[33] gnd reram_bitcell_7
Xbit_r34_c12 bl[12] br[12] wl[34] gnd reram_bitcell_7
Xbit_r35_c12 bl[12] br[12] wl[35] gnd reram_bitcell_7
Xbit_r36_c12 bl[12] br[12] wl[36] gnd reram_bitcell_7
Xbit_r37_c12 bl[12] br[12] wl[37] gnd reram_bitcell_7
Xbit_r38_c12 bl[12] br[12] wl[38] gnd reram_bitcell_7
Xbit_r39_c12 bl[12] br[12] wl[39] gnd reram_bitcell_7
Xbit_r40_c12 bl[12] br[12] wl[40] gnd reram_bitcell_7
Xbit_r41_c12 bl[12] br[12] wl[41] gnd reram_bitcell_7
Xbit_r42_c12 bl[12] br[12] wl[42] gnd reram_bitcell_7
Xbit_r43_c12 bl[12] br[12] wl[43] gnd reram_bitcell_7
Xbit_r44_c12 bl[12] br[12] wl[44] gnd reram_bitcell_7
Xbit_r45_c12 bl[12] br[12] wl[45] gnd reram_bitcell_7
Xbit_r46_c12 bl[12] br[12] wl[46] gnd reram_bitcell_7
Xbit_r47_c12 bl[12] br[12] wl[47] gnd reram_bitcell_7
Xbit_r48_c12 bl[12] br[12] wl[48] gnd reram_bitcell_7
Xbit_r49_c12 bl[12] br[12] wl[49] gnd reram_bitcell_7
Xbit_r50_c12 bl[12] br[12] wl[50] gnd reram_bitcell_7
Xbit_r51_c12 bl[12] br[12] wl[51] gnd reram_bitcell_7
Xbit_r52_c12 bl[12] br[12] wl[52] gnd reram_bitcell_7
Xbit_r53_c12 bl[12] br[12] wl[53] gnd reram_bitcell_7
Xbit_r54_c12 bl[12] br[12] wl[54] gnd reram_bitcell_7
Xbit_r55_c12 bl[12] br[12] wl[55] gnd reram_bitcell_7
Xbit_r56_c12 bl[12] br[12] wl[56] gnd reram_bitcell_7
Xbit_r57_c12 bl[12] br[12] wl[57] gnd reram_bitcell_7
Xbit_r58_c12 bl[12] br[12] wl[58] gnd reram_bitcell_7
Xbit_r59_c12 bl[12] br[12] wl[59] gnd reram_bitcell_7
Xbit_r60_c12 bl[12] br[12] wl[60] gnd reram_bitcell_7
Xbit_r61_c12 bl[12] br[12] wl[61] gnd reram_bitcell_7
Xbit_r62_c12 bl[12] br[12] wl[62] gnd reram_bitcell_7
Xbit_r63_c12 bl[12] br[12] wl[63] gnd reram_bitcell_7
Xbit_r0_c13 bl[13] br[13] wl[0] gnd reram_bitcell_7
Xbit_r1_c13 bl[13] br[13] wl[1] gnd reram_bitcell_7
Xbit_r2_c13 bl[13] br[13] wl[2] gnd reram_bitcell_7
Xbit_r3_c13 bl[13] br[13] wl[3] gnd reram_bitcell_7
Xbit_r4_c13 bl[13] br[13] wl[4] gnd reram_bitcell_7
Xbit_r5_c13 bl[13] br[13] wl[5] gnd reram_bitcell_7
Xbit_r6_c13 bl[13] br[13] wl[6] gnd reram_bitcell_7
Xbit_r7_c13 bl[13] br[13] wl[7] gnd reram_bitcell_7
Xbit_r8_c13 bl[13] br[13] wl[8] gnd reram_bitcell_7
Xbit_r9_c13 bl[13] br[13] wl[9] gnd reram_bitcell_7
Xbit_r10_c13 bl[13] br[13] wl[10] gnd reram_bitcell_7
Xbit_r11_c13 bl[13] br[13] wl[11] gnd reram_bitcell_7
Xbit_r12_c13 bl[13] br[13] wl[12] gnd reram_bitcell_7
Xbit_r13_c13 bl[13] br[13] wl[13] gnd reram_bitcell_7
Xbit_r14_c13 bl[13] br[13] wl[14] gnd reram_bitcell_7
Xbit_r15_c13 bl[13] br[13] wl[15] gnd reram_bitcell_7
Xbit_r16_c13 bl[13] br[13] wl[16] gnd reram_bitcell_7
Xbit_r17_c13 bl[13] br[13] wl[17] gnd reram_bitcell_7
Xbit_r18_c13 bl[13] br[13] wl[18] gnd reram_bitcell_7
Xbit_r19_c13 bl[13] br[13] wl[19] gnd reram_bitcell_7
Xbit_r20_c13 bl[13] br[13] wl[20] gnd reram_bitcell_7
Xbit_r21_c13 bl[13] br[13] wl[21] gnd reram_bitcell_7
Xbit_r22_c13 bl[13] br[13] wl[22] gnd reram_bitcell_7
Xbit_r23_c13 bl[13] br[13] wl[23] gnd reram_bitcell_7
Xbit_r24_c13 bl[13] br[13] wl[24] gnd reram_bitcell_7
Xbit_r25_c13 bl[13] br[13] wl[25] gnd reram_bitcell_7
Xbit_r26_c13 bl[13] br[13] wl[26] gnd reram_bitcell_7
Xbit_r27_c13 bl[13] br[13] wl[27] gnd reram_bitcell_7
Xbit_r28_c13 bl[13] br[13] wl[28] gnd reram_bitcell_7
Xbit_r29_c13 bl[13] br[13] wl[29] gnd reram_bitcell_7
Xbit_r30_c13 bl[13] br[13] wl[30] gnd reram_bitcell_7
Xbit_r31_c13 bl[13] br[13] wl[31] gnd reram_bitcell_7
Xbit_r32_c13 bl[13] br[13] wl[32] gnd reram_bitcell_7
Xbit_r33_c13 bl[13] br[13] wl[33] gnd reram_bitcell_7
Xbit_r34_c13 bl[13] br[13] wl[34] gnd reram_bitcell_7
Xbit_r35_c13 bl[13] br[13] wl[35] gnd reram_bitcell_7
Xbit_r36_c13 bl[13] br[13] wl[36] gnd reram_bitcell_7
Xbit_r37_c13 bl[13] br[13] wl[37] gnd reram_bitcell_7
Xbit_r38_c13 bl[13] br[13] wl[38] gnd reram_bitcell_7
Xbit_r39_c13 bl[13] br[13] wl[39] gnd reram_bitcell_7
Xbit_r40_c13 bl[13] br[13] wl[40] gnd reram_bitcell_7
Xbit_r41_c13 bl[13] br[13] wl[41] gnd reram_bitcell_7
Xbit_r42_c13 bl[13] br[13] wl[42] gnd reram_bitcell_7
Xbit_r43_c13 bl[13] br[13] wl[43] gnd reram_bitcell_7
Xbit_r44_c13 bl[13] br[13] wl[44] gnd reram_bitcell_7
Xbit_r45_c13 bl[13] br[13] wl[45] gnd reram_bitcell_7
Xbit_r46_c13 bl[13] br[13] wl[46] gnd reram_bitcell_7
Xbit_r47_c13 bl[13] br[13] wl[47] gnd reram_bitcell_7
Xbit_r48_c13 bl[13] br[13] wl[48] gnd reram_bitcell_7
Xbit_r49_c13 bl[13] br[13] wl[49] gnd reram_bitcell_7
Xbit_r50_c13 bl[13] br[13] wl[50] gnd reram_bitcell_7
Xbit_r51_c13 bl[13] br[13] wl[51] gnd reram_bitcell_7
Xbit_r52_c13 bl[13] br[13] wl[52] gnd reram_bitcell_7
Xbit_r53_c13 bl[13] br[13] wl[53] gnd reram_bitcell_7
Xbit_r54_c13 bl[13] br[13] wl[54] gnd reram_bitcell_7
Xbit_r55_c13 bl[13] br[13] wl[55] gnd reram_bitcell_7
Xbit_r56_c13 bl[13] br[13] wl[56] gnd reram_bitcell_7
Xbit_r57_c13 bl[13] br[13] wl[57] gnd reram_bitcell_7
Xbit_r58_c13 bl[13] br[13] wl[58] gnd reram_bitcell_7
Xbit_r59_c13 bl[13] br[13] wl[59] gnd reram_bitcell_7
Xbit_r60_c13 bl[13] br[13] wl[60] gnd reram_bitcell_7
Xbit_r61_c13 bl[13] br[13] wl[61] gnd reram_bitcell_7
Xbit_r62_c13 bl[13] br[13] wl[62] gnd reram_bitcell_7
Xbit_r63_c13 bl[13] br[13] wl[63] gnd reram_bitcell_7
Xbit_r0_c14 bl[14] br[14] wl[0] gnd reram_bitcell_7
Xbit_r1_c14 bl[14] br[14] wl[1] gnd reram_bitcell_7
Xbit_r2_c14 bl[14] br[14] wl[2] gnd reram_bitcell_7
Xbit_r3_c14 bl[14] br[14] wl[3] gnd reram_bitcell_7
Xbit_r4_c14 bl[14] br[14] wl[4] gnd reram_bitcell_7
Xbit_r5_c14 bl[14] br[14] wl[5] gnd reram_bitcell_7
Xbit_r6_c14 bl[14] br[14] wl[6] gnd reram_bitcell_7
Xbit_r7_c14 bl[14] br[14] wl[7] gnd reram_bitcell_7
Xbit_r8_c14 bl[14] br[14] wl[8] gnd reram_bitcell_7
Xbit_r9_c14 bl[14] br[14] wl[9] gnd reram_bitcell_7
Xbit_r10_c14 bl[14] br[14] wl[10] gnd reram_bitcell_7
Xbit_r11_c14 bl[14] br[14] wl[11] gnd reram_bitcell_7
Xbit_r12_c14 bl[14] br[14] wl[12] gnd reram_bitcell_7
Xbit_r13_c14 bl[14] br[14] wl[13] gnd reram_bitcell_7
Xbit_r14_c14 bl[14] br[14] wl[14] gnd reram_bitcell_7
Xbit_r15_c14 bl[14] br[14] wl[15] gnd reram_bitcell_7
Xbit_r16_c14 bl[14] br[14] wl[16] gnd reram_bitcell_7
Xbit_r17_c14 bl[14] br[14] wl[17] gnd reram_bitcell_7
Xbit_r18_c14 bl[14] br[14] wl[18] gnd reram_bitcell_7
Xbit_r19_c14 bl[14] br[14] wl[19] gnd reram_bitcell_7
Xbit_r20_c14 bl[14] br[14] wl[20] gnd reram_bitcell_7
Xbit_r21_c14 bl[14] br[14] wl[21] gnd reram_bitcell_7
Xbit_r22_c14 bl[14] br[14] wl[22] gnd reram_bitcell_7
Xbit_r23_c14 bl[14] br[14] wl[23] gnd reram_bitcell_7
Xbit_r24_c14 bl[14] br[14] wl[24] gnd reram_bitcell_7
Xbit_r25_c14 bl[14] br[14] wl[25] gnd reram_bitcell_7
Xbit_r26_c14 bl[14] br[14] wl[26] gnd reram_bitcell_7
Xbit_r27_c14 bl[14] br[14] wl[27] gnd reram_bitcell_7
Xbit_r28_c14 bl[14] br[14] wl[28] gnd reram_bitcell_7
Xbit_r29_c14 bl[14] br[14] wl[29] gnd reram_bitcell_7
Xbit_r30_c14 bl[14] br[14] wl[30] gnd reram_bitcell_7
Xbit_r31_c14 bl[14] br[14] wl[31] gnd reram_bitcell_7
Xbit_r32_c14 bl[14] br[14] wl[32] gnd reram_bitcell_7
Xbit_r33_c14 bl[14] br[14] wl[33] gnd reram_bitcell_7
Xbit_r34_c14 bl[14] br[14] wl[34] gnd reram_bitcell_7
Xbit_r35_c14 bl[14] br[14] wl[35] gnd reram_bitcell_7
Xbit_r36_c14 bl[14] br[14] wl[36] gnd reram_bitcell_7
Xbit_r37_c14 bl[14] br[14] wl[37] gnd reram_bitcell_7
Xbit_r38_c14 bl[14] br[14] wl[38] gnd reram_bitcell_7
Xbit_r39_c14 bl[14] br[14] wl[39] gnd reram_bitcell_7
Xbit_r40_c14 bl[14] br[14] wl[40] gnd reram_bitcell_7
Xbit_r41_c14 bl[14] br[14] wl[41] gnd reram_bitcell_7
Xbit_r42_c14 bl[14] br[14] wl[42] gnd reram_bitcell_7
Xbit_r43_c14 bl[14] br[14] wl[43] gnd reram_bitcell_7
Xbit_r44_c14 bl[14] br[14] wl[44] gnd reram_bitcell_7
Xbit_r45_c14 bl[14] br[14] wl[45] gnd reram_bitcell_7
Xbit_r46_c14 bl[14] br[14] wl[46] gnd reram_bitcell_7
Xbit_r47_c14 bl[14] br[14] wl[47] gnd reram_bitcell_7
Xbit_r48_c14 bl[14] br[14] wl[48] gnd reram_bitcell_7
Xbit_r49_c14 bl[14] br[14] wl[49] gnd reram_bitcell_7
Xbit_r50_c14 bl[14] br[14] wl[50] gnd reram_bitcell_7
Xbit_r51_c14 bl[14] br[14] wl[51] gnd reram_bitcell_7
Xbit_r52_c14 bl[14] br[14] wl[52] gnd reram_bitcell_7
Xbit_r53_c14 bl[14] br[14] wl[53] gnd reram_bitcell_7
Xbit_r54_c14 bl[14] br[14] wl[54] gnd reram_bitcell_7
Xbit_r55_c14 bl[14] br[14] wl[55] gnd reram_bitcell_7
Xbit_r56_c14 bl[14] br[14] wl[56] gnd reram_bitcell_7
Xbit_r57_c14 bl[14] br[14] wl[57] gnd reram_bitcell_7
Xbit_r58_c14 bl[14] br[14] wl[58] gnd reram_bitcell_7
Xbit_r59_c14 bl[14] br[14] wl[59] gnd reram_bitcell_7
Xbit_r60_c14 bl[14] br[14] wl[60] gnd reram_bitcell_7
Xbit_r61_c14 bl[14] br[14] wl[61] gnd reram_bitcell_7
Xbit_r62_c14 bl[14] br[14] wl[62] gnd reram_bitcell_7
Xbit_r63_c14 bl[14] br[14] wl[63] gnd reram_bitcell_7
Xbit_r0_c15 bl[15] br[15] wl[0] gnd reram_bitcell_7
Xbit_r1_c15 bl[15] br[15] wl[1] gnd reram_bitcell_7
Xbit_r2_c15 bl[15] br[15] wl[2] gnd reram_bitcell_7
Xbit_r3_c15 bl[15] br[15] wl[3] gnd reram_bitcell_7
Xbit_r4_c15 bl[15] br[15] wl[4] gnd reram_bitcell_7
Xbit_r5_c15 bl[15] br[15] wl[5] gnd reram_bitcell_7
Xbit_r6_c15 bl[15] br[15] wl[6] gnd reram_bitcell_7
Xbit_r7_c15 bl[15] br[15] wl[7] gnd reram_bitcell_7
Xbit_r8_c15 bl[15] br[15] wl[8] gnd reram_bitcell_7
Xbit_r9_c15 bl[15] br[15] wl[9] gnd reram_bitcell_7
Xbit_r10_c15 bl[15] br[15] wl[10] gnd reram_bitcell_7
Xbit_r11_c15 bl[15] br[15] wl[11] gnd reram_bitcell_7
Xbit_r12_c15 bl[15] br[15] wl[12] gnd reram_bitcell_7
Xbit_r13_c15 bl[15] br[15] wl[13] gnd reram_bitcell_7
Xbit_r14_c15 bl[15] br[15] wl[14] gnd reram_bitcell_7
Xbit_r15_c15 bl[15] br[15] wl[15] gnd reram_bitcell_7
Xbit_r16_c15 bl[15] br[15] wl[16] gnd reram_bitcell_7
Xbit_r17_c15 bl[15] br[15] wl[17] gnd reram_bitcell_7
Xbit_r18_c15 bl[15] br[15] wl[18] gnd reram_bitcell_7
Xbit_r19_c15 bl[15] br[15] wl[19] gnd reram_bitcell_7
Xbit_r20_c15 bl[15] br[15] wl[20] gnd reram_bitcell_7
Xbit_r21_c15 bl[15] br[15] wl[21] gnd reram_bitcell_7
Xbit_r22_c15 bl[15] br[15] wl[22] gnd reram_bitcell_7
Xbit_r23_c15 bl[15] br[15] wl[23] gnd reram_bitcell_7
Xbit_r24_c15 bl[15] br[15] wl[24] gnd reram_bitcell_7
Xbit_r25_c15 bl[15] br[15] wl[25] gnd reram_bitcell_7
Xbit_r26_c15 bl[15] br[15] wl[26] gnd reram_bitcell_7
Xbit_r27_c15 bl[15] br[15] wl[27] gnd reram_bitcell_7
Xbit_r28_c15 bl[15] br[15] wl[28] gnd reram_bitcell_7
Xbit_r29_c15 bl[15] br[15] wl[29] gnd reram_bitcell_7
Xbit_r30_c15 bl[15] br[15] wl[30] gnd reram_bitcell_7
Xbit_r31_c15 bl[15] br[15] wl[31] gnd reram_bitcell_7
Xbit_r32_c15 bl[15] br[15] wl[32] gnd reram_bitcell_7
Xbit_r33_c15 bl[15] br[15] wl[33] gnd reram_bitcell_7
Xbit_r34_c15 bl[15] br[15] wl[34] gnd reram_bitcell_7
Xbit_r35_c15 bl[15] br[15] wl[35] gnd reram_bitcell_7
Xbit_r36_c15 bl[15] br[15] wl[36] gnd reram_bitcell_7
Xbit_r37_c15 bl[15] br[15] wl[37] gnd reram_bitcell_7
Xbit_r38_c15 bl[15] br[15] wl[38] gnd reram_bitcell_7
Xbit_r39_c15 bl[15] br[15] wl[39] gnd reram_bitcell_7
Xbit_r40_c15 bl[15] br[15] wl[40] gnd reram_bitcell_7
Xbit_r41_c15 bl[15] br[15] wl[41] gnd reram_bitcell_7
Xbit_r42_c15 bl[15] br[15] wl[42] gnd reram_bitcell_7
Xbit_r43_c15 bl[15] br[15] wl[43] gnd reram_bitcell_7
Xbit_r44_c15 bl[15] br[15] wl[44] gnd reram_bitcell_7
Xbit_r45_c15 bl[15] br[15] wl[45] gnd reram_bitcell_7
Xbit_r46_c15 bl[15] br[15] wl[46] gnd reram_bitcell_7
Xbit_r47_c15 bl[15] br[15] wl[47] gnd reram_bitcell_7
Xbit_r48_c15 bl[15] br[15] wl[48] gnd reram_bitcell_7
Xbit_r49_c15 bl[15] br[15] wl[49] gnd reram_bitcell_7
Xbit_r50_c15 bl[15] br[15] wl[50] gnd reram_bitcell_7
Xbit_r51_c15 bl[15] br[15] wl[51] gnd reram_bitcell_7
Xbit_r52_c15 bl[15] br[15] wl[52] gnd reram_bitcell_7
Xbit_r53_c15 bl[15] br[15] wl[53] gnd reram_bitcell_7
Xbit_r54_c15 bl[15] br[15] wl[54] gnd reram_bitcell_7
Xbit_r55_c15 bl[15] br[15] wl[55] gnd reram_bitcell_7
Xbit_r56_c15 bl[15] br[15] wl[56] gnd reram_bitcell_7
Xbit_r57_c15 bl[15] br[15] wl[57] gnd reram_bitcell_7
Xbit_r58_c15 bl[15] br[15] wl[58] gnd reram_bitcell_7
Xbit_r59_c15 bl[15] br[15] wl[59] gnd reram_bitcell_7
Xbit_r60_c15 bl[15] br[15] wl[60] gnd reram_bitcell_7
Xbit_r61_c15 bl[15] br[15] wl[61] gnd reram_bitcell_7
Xbit_r62_c15 bl[15] br[15] wl[62] gnd reram_bitcell_7
Xbit_r63_c15 bl[15] br[15] wl[63] gnd reram_bitcell_7
Xbit_r0_c16 bl[16] br[16] wl[0] gnd reram_bitcell_7
Xbit_r1_c16 bl[16] br[16] wl[1] gnd reram_bitcell_7
Xbit_r2_c16 bl[16] br[16] wl[2] gnd reram_bitcell_7
Xbit_r3_c16 bl[16] br[16] wl[3] gnd reram_bitcell_7
Xbit_r4_c16 bl[16] br[16] wl[4] gnd reram_bitcell_7
Xbit_r5_c16 bl[16] br[16] wl[5] gnd reram_bitcell_7
Xbit_r6_c16 bl[16] br[16] wl[6] gnd reram_bitcell_7
Xbit_r7_c16 bl[16] br[16] wl[7] gnd reram_bitcell_7
Xbit_r8_c16 bl[16] br[16] wl[8] gnd reram_bitcell_7
Xbit_r9_c16 bl[16] br[16] wl[9] gnd reram_bitcell_7
Xbit_r10_c16 bl[16] br[16] wl[10] gnd reram_bitcell_7
Xbit_r11_c16 bl[16] br[16] wl[11] gnd reram_bitcell_7
Xbit_r12_c16 bl[16] br[16] wl[12] gnd reram_bitcell_7
Xbit_r13_c16 bl[16] br[16] wl[13] gnd reram_bitcell_7
Xbit_r14_c16 bl[16] br[16] wl[14] gnd reram_bitcell_7
Xbit_r15_c16 bl[16] br[16] wl[15] gnd reram_bitcell_7
Xbit_r16_c16 bl[16] br[16] wl[16] gnd reram_bitcell_7
Xbit_r17_c16 bl[16] br[16] wl[17] gnd reram_bitcell_7
Xbit_r18_c16 bl[16] br[16] wl[18] gnd reram_bitcell_7
Xbit_r19_c16 bl[16] br[16] wl[19] gnd reram_bitcell_7
Xbit_r20_c16 bl[16] br[16] wl[20] gnd reram_bitcell_7
Xbit_r21_c16 bl[16] br[16] wl[21] gnd reram_bitcell_7
Xbit_r22_c16 bl[16] br[16] wl[22] gnd reram_bitcell_7
Xbit_r23_c16 bl[16] br[16] wl[23] gnd reram_bitcell_7
Xbit_r24_c16 bl[16] br[16] wl[24] gnd reram_bitcell_7
Xbit_r25_c16 bl[16] br[16] wl[25] gnd reram_bitcell_7
Xbit_r26_c16 bl[16] br[16] wl[26] gnd reram_bitcell_7
Xbit_r27_c16 bl[16] br[16] wl[27] gnd reram_bitcell_7
Xbit_r28_c16 bl[16] br[16] wl[28] gnd reram_bitcell_7
Xbit_r29_c16 bl[16] br[16] wl[29] gnd reram_bitcell_7
Xbit_r30_c16 bl[16] br[16] wl[30] gnd reram_bitcell_7
Xbit_r31_c16 bl[16] br[16] wl[31] gnd reram_bitcell_7
Xbit_r32_c16 bl[16] br[16] wl[32] gnd reram_bitcell_7
Xbit_r33_c16 bl[16] br[16] wl[33] gnd reram_bitcell_7
Xbit_r34_c16 bl[16] br[16] wl[34] gnd reram_bitcell_7
Xbit_r35_c16 bl[16] br[16] wl[35] gnd reram_bitcell_7
Xbit_r36_c16 bl[16] br[16] wl[36] gnd reram_bitcell_7
Xbit_r37_c16 bl[16] br[16] wl[37] gnd reram_bitcell_7
Xbit_r38_c16 bl[16] br[16] wl[38] gnd reram_bitcell_7
Xbit_r39_c16 bl[16] br[16] wl[39] gnd reram_bitcell_7
Xbit_r40_c16 bl[16] br[16] wl[40] gnd reram_bitcell_7
Xbit_r41_c16 bl[16] br[16] wl[41] gnd reram_bitcell_7
Xbit_r42_c16 bl[16] br[16] wl[42] gnd reram_bitcell_7
Xbit_r43_c16 bl[16] br[16] wl[43] gnd reram_bitcell_7
Xbit_r44_c16 bl[16] br[16] wl[44] gnd reram_bitcell_7
Xbit_r45_c16 bl[16] br[16] wl[45] gnd reram_bitcell_7
Xbit_r46_c16 bl[16] br[16] wl[46] gnd reram_bitcell_7
Xbit_r47_c16 bl[16] br[16] wl[47] gnd reram_bitcell_7
Xbit_r48_c16 bl[16] br[16] wl[48] gnd reram_bitcell_7
Xbit_r49_c16 bl[16] br[16] wl[49] gnd reram_bitcell_7
Xbit_r50_c16 bl[16] br[16] wl[50] gnd reram_bitcell_7
Xbit_r51_c16 bl[16] br[16] wl[51] gnd reram_bitcell_7
Xbit_r52_c16 bl[16] br[16] wl[52] gnd reram_bitcell_7
Xbit_r53_c16 bl[16] br[16] wl[53] gnd reram_bitcell_7
Xbit_r54_c16 bl[16] br[16] wl[54] gnd reram_bitcell_7
Xbit_r55_c16 bl[16] br[16] wl[55] gnd reram_bitcell_7
Xbit_r56_c16 bl[16] br[16] wl[56] gnd reram_bitcell_7
Xbit_r57_c16 bl[16] br[16] wl[57] gnd reram_bitcell_7
Xbit_r58_c16 bl[16] br[16] wl[58] gnd reram_bitcell_7
Xbit_r59_c16 bl[16] br[16] wl[59] gnd reram_bitcell_7
Xbit_r60_c16 bl[16] br[16] wl[60] gnd reram_bitcell_7
Xbit_r61_c16 bl[16] br[16] wl[61] gnd reram_bitcell_7
Xbit_r62_c16 bl[16] br[16] wl[62] gnd reram_bitcell_7
Xbit_r63_c16 bl[16] br[16] wl[63] gnd reram_bitcell_7
Xbit_r0_c17 bl[17] br[17] wl[0] gnd reram_bitcell_7
Xbit_r1_c17 bl[17] br[17] wl[1] gnd reram_bitcell_7
Xbit_r2_c17 bl[17] br[17] wl[2] gnd reram_bitcell_7
Xbit_r3_c17 bl[17] br[17] wl[3] gnd reram_bitcell_7
Xbit_r4_c17 bl[17] br[17] wl[4] gnd reram_bitcell_7
Xbit_r5_c17 bl[17] br[17] wl[5] gnd reram_bitcell_7
Xbit_r6_c17 bl[17] br[17] wl[6] gnd reram_bitcell_7
Xbit_r7_c17 bl[17] br[17] wl[7] gnd reram_bitcell_7
Xbit_r8_c17 bl[17] br[17] wl[8] gnd reram_bitcell_7
Xbit_r9_c17 bl[17] br[17] wl[9] gnd reram_bitcell_7
Xbit_r10_c17 bl[17] br[17] wl[10] gnd reram_bitcell_7
Xbit_r11_c17 bl[17] br[17] wl[11] gnd reram_bitcell_7
Xbit_r12_c17 bl[17] br[17] wl[12] gnd reram_bitcell_7
Xbit_r13_c17 bl[17] br[17] wl[13] gnd reram_bitcell_7
Xbit_r14_c17 bl[17] br[17] wl[14] gnd reram_bitcell_7
Xbit_r15_c17 bl[17] br[17] wl[15] gnd reram_bitcell_7
Xbit_r16_c17 bl[17] br[17] wl[16] gnd reram_bitcell_7
Xbit_r17_c17 bl[17] br[17] wl[17] gnd reram_bitcell_7
Xbit_r18_c17 bl[17] br[17] wl[18] gnd reram_bitcell_7
Xbit_r19_c17 bl[17] br[17] wl[19] gnd reram_bitcell_7
Xbit_r20_c17 bl[17] br[17] wl[20] gnd reram_bitcell_7
Xbit_r21_c17 bl[17] br[17] wl[21] gnd reram_bitcell_7
Xbit_r22_c17 bl[17] br[17] wl[22] gnd reram_bitcell_7
Xbit_r23_c17 bl[17] br[17] wl[23] gnd reram_bitcell_7
Xbit_r24_c17 bl[17] br[17] wl[24] gnd reram_bitcell_7
Xbit_r25_c17 bl[17] br[17] wl[25] gnd reram_bitcell_7
Xbit_r26_c17 bl[17] br[17] wl[26] gnd reram_bitcell_7
Xbit_r27_c17 bl[17] br[17] wl[27] gnd reram_bitcell_7
Xbit_r28_c17 bl[17] br[17] wl[28] gnd reram_bitcell_7
Xbit_r29_c17 bl[17] br[17] wl[29] gnd reram_bitcell_7
Xbit_r30_c17 bl[17] br[17] wl[30] gnd reram_bitcell_7
Xbit_r31_c17 bl[17] br[17] wl[31] gnd reram_bitcell_7
Xbit_r32_c17 bl[17] br[17] wl[32] gnd reram_bitcell_7
Xbit_r33_c17 bl[17] br[17] wl[33] gnd reram_bitcell_7
Xbit_r34_c17 bl[17] br[17] wl[34] gnd reram_bitcell_7
Xbit_r35_c17 bl[17] br[17] wl[35] gnd reram_bitcell_7
Xbit_r36_c17 bl[17] br[17] wl[36] gnd reram_bitcell_7
Xbit_r37_c17 bl[17] br[17] wl[37] gnd reram_bitcell_7
Xbit_r38_c17 bl[17] br[17] wl[38] gnd reram_bitcell_7
Xbit_r39_c17 bl[17] br[17] wl[39] gnd reram_bitcell_7
Xbit_r40_c17 bl[17] br[17] wl[40] gnd reram_bitcell_7
Xbit_r41_c17 bl[17] br[17] wl[41] gnd reram_bitcell_7
Xbit_r42_c17 bl[17] br[17] wl[42] gnd reram_bitcell_7
Xbit_r43_c17 bl[17] br[17] wl[43] gnd reram_bitcell_7
Xbit_r44_c17 bl[17] br[17] wl[44] gnd reram_bitcell_7
Xbit_r45_c17 bl[17] br[17] wl[45] gnd reram_bitcell_7
Xbit_r46_c17 bl[17] br[17] wl[46] gnd reram_bitcell_7
Xbit_r47_c17 bl[17] br[17] wl[47] gnd reram_bitcell_7
Xbit_r48_c17 bl[17] br[17] wl[48] gnd reram_bitcell_7
Xbit_r49_c17 bl[17] br[17] wl[49] gnd reram_bitcell_7
Xbit_r50_c17 bl[17] br[17] wl[50] gnd reram_bitcell_7
Xbit_r51_c17 bl[17] br[17] wl[51] gnd reram_bitcell_7
Xbit_r52_c17 bl[17] br[17] wl[52] gnd reram_bitcell_7
Xbit_r53_c17 bl[17] br[17] wl[53] gnd reram_bitcell_7
Xbit_r54_c17 bl[17] br[17] wl[54] gnd reram_bitcell_7
Xbit_r55_c17 bl[17] br[17] wl[55] gnd reram_bitcell_7
Xbit_r56_c17 bl[17] br[17] wl[56] gnd reram_bitcell_7
Xbit_r57_c17 bl[17] br[17] wl[57] gnd reram_bitcell_7
Xbit_r58_c17 bl[17] br[17] wl[58] gnd reram_bitcell_7
Xbit_r59_c17 bl[17] br[17] wl[59] gnd reram_bitcell_7
Xbit_r60_c17 bl[17] br[17] wl[60] gnd reram_bitcell_7
Xbit_r61_c17 bl[17] br[17] wl[61] gnd reram_bitcell_7
Xbit_r62_c17 bl[17] br[17] wl[62] gnd reram_bitcell_7
Xbit_r63_c17 bl[17] br[17] wl[63] gnd reram_bitcell_7
Xbit_r0_c18 bl[18] br[18] wl[0] gnd reram_bitcell_7
Xbit_r1_c18 bl[18] br[18] wl[1] gnd reram_bitcell_7
Xbit_r2_c18 bl[18] br[18] wl[2] gnd reram_bitcell_7
Xbit_r3_c18 bl[18] br[18] wl[3] gnd reram_bitcell_7
Xbit_r4_c18 bl[18] br[18] wl[4] gnd reram_bitcell_7
Xbit_r5_c18 bl[18] br[18] wl[5] gnd reram_bitcell_7
Xbit_r6_c18 bl[18] br[18] wl[6] gnd reram_bitcell_7
Xbit_r7_c18 bl[18] br[18] wl[7] gnd reram_bitcell_7
Xbit_r8_c18 bl[18] br[18] wl[8] gnd reram_bitcell_7
Xbit_r9_c18 bl[18] br[18] wl[9] gnd reram_bitcell_7
Xbit_r10_c18 bl[18] br[18] wl[10] gnd reram_bitcell_7
Xbit_r11_c18 bl[18] br[18] wl[11] gnd reram_bitcell_7
Xbit_r12_c18 bl[18] br[18] wl[12] gnd reram_bitcell_7
Xbit_r13_c18 bl[18] br[18] wl[13] gnd reram_bitcell_7
Xbit_r14_c18 bl[18] br[18] wl[14] gnd reram_bitcell_7
Xbit_r15_c18 bl[18] br[18] wl[15] gnd reram_bitcell_7
Xbit_r16_c18 bl[18] br[18] wl[16] gnd reram_bitcell_7
Xbit_r17_c18 bl[18] br[18] wl[17] gnd reram_bitcell_7
Xbit_r18_c18 bl[18] br[18] wl[18] gnd reram_bitcell_7
Xbit_r19_c18 bl[18] br[18] wl[19] gnd reram_bitcell_7
Xbit_r20_c18 bl[18] br[18] wl[20] gnd reram_bitcell_7
Xbit_r21_c18 bl[18] br[18] wl[21] gnd reram_bitcell_7
Xbit_r22_c18 bl[18] br[18] wl[22] gnd reram_bitcell_7
Xbit_r23_c18 bl[18] br[18] wl[23] gnd reram_bitcell_7
Xbit_r24_c18 bl[18] br[18] wl[24] gnd reram_bitcell_7
Xbit_r25_c18 bl[18] br[18] wl[25] gnd reram_bitcell_7
Xbit_r26_c18 bl[18] br[18] wl[26] gnd reram_bitcell_7
Xbit_r27_c18 bl[18] br[18] wl[27] gnd reram_bitcell_7
Xbit_r28_c18 bl[18] br[18] wl[28] gnd reram_bitcell_7
Xbit_r29_c18 bl[18] br[18] wl[29] gnd reram_bitcell_7
Xbit_r30_c18 bl[18] br[18] wl[30] gnd reram_bitcell_7
Xbit_r31_c18 bl[18] br[18] wl[31] gnd reram_bitcell_7
Xbit_r32_c18 bl[18] br[18] wl[32] gnd reram_bitcell_7
Xbit_r33_c18 bl[18] br[18] wl[33] gnd reram_bitcell_7
Xbit_r34_c18 bl[18] br[18] wl[34] gnd reram_bitcell_7
Xbit_r35_c18 bl[18] br[18] wl[35] gnd reram_bitcell_7
Xbit_r36_c18 bl[18] br[18] wl[36] gnd reram_bitcell_7
Xbit_r37_c18 bl[18] br[18] wl[37] gnd reram_bitcell_7
Xbit_r38_c18 bl[18] br[18] wl[38] gnd reram_bitcell_7
Xbit_r39_c18 bl[18] br[18] wl[39] gnd reram_bitcell_7
Xbit_r40_c18 bl[18] br[18] wl[40] gnd reram_bitcell_7
Xbit_r41_c18 bl[18] br[18] wl[41] gnd reram_bitcell_7
Xbit_r42_c18 bl[18] br[18] wl[42] gnd reram_bitcell_7
Xbit_r43_c18 bl[18] br[18] wl[43] gnd reram_bitcell_7
Xbit_r44_c18 bl[18] br[18] wl[44] gnd reram_bitcell_7
Xbit_r45_c18 bl[18] br[18] wl[45] gnd reram_bitcell_7
Xbit_r46_c18 bl[18] br[18] wl[46] gnd reram_bitcell_7
Xbit_r47_c18 bl[18] br[18] wl[47] gnd reram_bitcell_7
Xbit_r48_c18 bl[18] br[18] wl[48] gnd reram_bitcell_7
Xbit_r49_c18 bl[18] br[18] wl[49] gnd reram_bitcell_7
Xbit_r50_c18 bl[18] br[18] wl[50] gnd reram_bitcell_7
Xbit_r51_c18 bl[18] br[18] wl[51] gnd reram_bitcell_7
Xbit_r52_c18 bl[18] br[18] wl[52] gnd reram_bitcell_7
Xbit_r53_c18 bl[18] br[18] wl[53] gnd reram_bitcell_7
Xbit_r54_c18 bl[18] br[18] wl[54] gnd reram_bitcell_7
Xbit_r55_c18 bl[18] br[18] wl[55] gnd reram_bitcell_7
Xbit_r56_c18 bl[18] br[18] wl[56] gnd reram_bitcell_7
Xbit_r57_c18 bl[18] br[18] wl[57] gnd reram_bitcell_7
Xbit_r58_c18 bl[18] br[18] wl[58] gnd reram_bitcell_7
Xbit_r59_c18 bl[18] br[18] wl[59] gnd reram_bitcell_7
Xbit_r60_c18 bl[18] br[18] wl[60] gnd reram_bitcell_7
Xbit_r61_c18 bl[18] br[18] wl[61] gnd reram_bitcell_7
Xbit_r62_c18 bl[18] br[18] wl[62] gnd reram_bitcell_7
Xbit_r63_c18 bl[18] br[18] wl[63] gnd reram_bitcell_7
Xbit_r0_c19 bl[19] br[19] wl[0] gnd reram_bitcell_7
Xbit_r1_c19 bl[19] br[19] wl[1] gnd reram_bitcell_7
Xbit_r2_c19 bl[19] br[19] wl[2] gnd reram_bitcell_7
Xbit_r3_c19 bl[19] br[19] wl[3] gnd reram_bitcell_7
Xbit_r4_c19 bl[19] br[19] wl[4] gnd reram_bitcell_7
Xbit_r5_c19 bl[19] br[19] wl[5] gnd reram_bitcell_7
Xbit_r6_c19 bl[19] br[19] wl[6] gnd reram_bitcell_7
Xbit_r7_c19 bl[19] br[19] wl[7] gnd reram_bitcell_7
Xbit_r8_c19 bl[19] br[19] wl[8] gnd reram_bitcell_7
Xbit_r9_c19 bl[19] br[19] wl[9] gnd reram_bitcell_7
Xbit_r10_c19 bl[19] br[19] wl[10] gnd reram_bitcell_7
Xbit_r11_c19 bl[19] br[19] wl[11] gnd reram_bitcell_7
Xbit_r12_c19 bl[19] br[19] wl[12] gnd reram_bitcell_7
Xbit_r13_c19 bl[19] br[19] wl[13] gnd reram_bitcell_7
Xbit_r14_c19 bl[19] br[19] wl[14] gnd reram_bitcell_7
Xbit_r15_c19 bl[19] br[19] wl[15] gnd reram_bitcell_7
Xbit_r16_c19 bl[19] br[19] wl[16] gnd reram_bitcell_7
Xbit_r17_c19 bl[19] br[19] wl[17] gnd reram_bitcell_7
Xbit_r18_c19 bl[19] br[19] wl[18] gnd reram_bitcell_7
Xbit_r19_c19 bl[19] br[19] wl[19] gnd reram_bitcell_7
Xbit_r20_c19 bl[19] br[19] wl[20] gnd reram_bitcell_7
Xbit_r21_c19 bl[19] br[19] wl[21] gnd reram_bitcell_7
Xbit_r22_c19 bl[19] br[19] wl[22] gnd reram_bitcell_7
Xbit_r23_c19 bl[19] br[19] wl[23] gnd reram_bitcell_7
Xbit_r24_c19 bl[19] br[19] wl[24] gnd reram_bitcell_7
Xbit_r25_c19 bl[19] br[19] wl[25] gnd reram_bitcell_7
Xbit_r26_c19 bl[19] br[19] wl[26] gnd reram_bitcell_7
Xbit_r27_c19 bl[19] br[19] wl[27] gnd reram_bitcell_7
Xbit_r28_c19 bl[19] br[19] wl[28] gnd reram_bitcell_7
Xbit_r29_c19 bl[19] br[19] wl[29] gnd reram_bitcell_7
Xbit_r30_c19 bl[19] br[19] wl[30] gnd reram_bitcell_7
Xbit_r31_c19 bl[19] br[19] wl[31] gnd reram_bitcell_7
Xbit_r32_c19 bl[19] br[19] wl[32] gnd reram_bitcell_7
Xbit_r33_c19 bl[19] br[19] wl[33] gnd reram_bitcell_7
Xbit_r34_c19 bl[19] br[19] wl[34] gnd reram_bitcell_7
Xbit_r35_c19 bl[19] br[19] wl[35] gnd reram_bitcell_7
Xbit_r36_c19 bl[19] br[19] wl[36] gnd reram_bitcell_7
Xbit_r37_c19 bl[19] br[19] wl[37] gnd reram_bitcell_7
Xbit_r38_c19 bl[19] br[19] wl[38] gnd reram_bitcell_7
Xbit_r39_c19 bl[19] br[19] wl[39] gnd reram_bitcell_7
Xbit_r40_c19 bl[19] br[19] wl[40] gnd reram_bitcell_7
Xbit_r41_c19 bl[19] br[19] wl[41] gnd reram_bitcell_7
Xbit_r42_c19 bl[19] br[19] wl[42] gnd reram_bitcell_7
Xbit_r43_c19 bl[19] br[19] wl[43] gnd reram_bitcell_7
Xbit_r44_c19 bl[19] br[19] wl[44] gnd reram_bitcell_7
Xbit_r45_c19 bl[19] br[19] wl[45] gnd reram_bitcell_7
Xbit_r46_c19 bl[19] br[19] wl[46] gnd reram_bitcell_7
Xbit_r47_c19 bl[19] br[19] wl[47] gnd reram_bitcell_7
Xbit_r48_c19 bl[19] br[19] wl[48] gnd reram_bitcell_7
Xbit_r49_c19 bl[19] br[19] wl[49] gnd reram_bitcell_7
Xbit_r50_c19 bl[19] br[19] wl[50] gnd reram_bitcell_7
Xbit_r51_c19 bl[19] br[19] wl[51] gnd reram_bitcell_7
Xbit_r52_c19 bl[19] br[19] wl[52] gnd reram_bitcell_7
Xbit_r53_c19 bl[19] br[19] wl[53] gnd reram_bitcell_7
Xbit_r54_c19 bl[19] br[19] wl[54] gnd reram_bitcell_7
Xbit_r55_c19 bl[19] br[19] wl[55] gnd reram_bitcell_7
Xbit_r56_c19 bl[19] br[19] wl[56] gnd reram_bitcell_7
Xbit_r57_c19 bl[19] br[19] wl[57] gnd reram_bitcell_7
Xbit_r58_c19 bl[19] br[19] wl[58] gnd reram_bitcell_7
Xbit_r59_c19 bl[19] br[19] wl[59] gnd reram_bitcell_7
Xbit_r60_c19 bl[19] br[19] wl[60] gnd reram_bitcell_7
Xbit_r61_c19 bl[19] br[19] wl[61] gnd reram_bitcell_7
Xbit_r62_c19 bl[19] br[19] wl[62] gnd reram_bitcell_7
Xbit_r63_c19 bl[19] br[19] wl[63] gnd reram_bitcell_7
Xbit_r0_c20 bl[20] br[20] wl[0] gnd reram_bitcell_7
Xbit_r1_c20 bl[20] br[20] wl[1] gnd reram_bitcell_7
Xbit_r2_c20 bl[20] br[20] wl[2] gnd reram_bitcell_7
Xbit_r3_c20 bl[20] br[20] wl[3] gnd reram_bitcell_7
Xbit_r4_c20 bl[20] br[20] wl[4] gnd reram_bitcell_7
Xbit_r5_c20 bl[20] br[20] wl[5] gnd reram_bitcell_7
Xbit_r6_c20 bl[20] br[20] wl[6] gnd reram_bitcell_7
Xbit_r7_c20 bl[20] br[20] wl[7] gnd reram_bitcell_7
Xbit_r8_c20 bl[20] br[20] wl[8] gnd reram_bitcell_7
Xbit_r9_c20 bl[20] br[20] wl[9] gnd reram_bitcell_7
Xbit_r10_c20 bl[20] br[20] wl[10] gnd reram_bitcell_7
Xbit_r11_c20 bl[20] br[20] wl[11] gnd reram_bitcell_7
Xbit_r12_c20 bl[20] br[20] wl[12] gnd reram_bitcell_7
Xbit_r13_c20 bl[20] br[20] wl[13] gnd reram_bitcell_7
Xbit_r14_c20 bl[20] br[20] wl[14] gnd reram_bitcell_7
Xbit_r15_c20 bl[20] br[20] wl[15] gnd reram_bitcell_7
Xbit_r16_c20 bl[20] br[20] wl[16] gnd reram_bitcell_7
Xbit_r17_c20 bl[20] br[20] wl[17] gnd reram_bitcell_7
Xbit_r18_c20 bl[20] br[20] wl[18] gnd reram_bitcell_7
Xbit_r19_c20 bl[20] br[20] wl[19] gnd reram_bitcell_7
Xbit_r20_c20 bl[20] br[20] wl[20] gnd reram_bitcell_7
Xbit_r21_c20 bl[20] br[20] wl[21] gnd reram_bitcell_7
Xbit_r22_c20 bl[20] br[20] wl[22] gnd reram_bitcell_7
Xbit_r23_c20 bl[20] br[20] wl[23] gnd reram_bitcell_7
Xbit_r24_c20 bl[20] br[20] wl[24] gnd reram_bitcell_7
Xbit_r25_c20 bl[20] br[20] wl[25] gnd reram_bitcell_7
Xbit_r26_c20 bl[20] br[20] wl[26] gnd reram_bitcell_7
Xbit_r27_c20 bl[20] br[20] wl[27] gnd reram_bitcell_7
Xbit_r28_c20 bl[20] br[20] wl[28] gnd reram_bitcell_7
Xbit_r29_c20 bl[20] br[20] wl[29] gnd reram_bitcell_7
Xbit_r30_c20 bl[20] br[20] wl[30] gnd reram_bitcell_7
Xbit_r31_c20 bl[20] br[20] wl[31] gnd reram_bitcell_7
Xbit_r32_c20 bl[20] br[20] wl[32] gnd reram_bitcell_7
Xbit_r33_c20 bl[20] br[20] wl[33] gnd reram_bitcell_7
Xbit_r34_c20 bl[20] br[20] wl[34] gnd reram_bitcell_7
Xbit_r35_c20 bl[20] br[20] wl[35] gnd reram_bitcell_7
Xbit_r36_c20 bl[20] br[20] wl[36] gnd reram_bitcell_7
Xbit_r37_c20 bl[20] br[20] wl[37] gnd reram_bitcell_7
Xbit_r38_c20 bl[20] br[20] wl[38] gnd reram_bitcell_7
Xbit_r39_c20 bl[20] br[20] wl[39] gnd reram_bitcell_7
Xbit_r40_c20 bl[20] br[20] wl[40] gnd reram_bitcell_7
Xbit_r41_c20 bl[20] br[20] wl[41] gnd reram_bitcell_7
Xbit_r42_c20 bl[20] br[20] wl[42] gnd reram_bitcell_7
Xbit_r43_c20 bl[20] br[20] wl[43] gnd reram_bitcell_7
Xbit_r44_c20 bl[20] br[20] wl[44] gnd reram_bitcell_7
Xbit_r45_c20 bl[20] br[20] wl[45] gnd reram_bitcell_7
Xbit_r46_c20 bl[20] br[20] wl[46] gnd reram_bitcell_7
Xbit_r47_c20 bl[20] br[20] wl[47] gnd reram_bitcell_7
Xbit_r48_c20 bl[20] br[20] wl[48] gnd reram_bitcell_7
Xbit_r49_c20 bl[20] br[20] wl[49] gnd reram_bitcell_7
Xbit_r50_c20 bl[20] br[20] wl[50] gnd reram_bitcell_7
Xbit_r51_c20 bl[20] br[20] wl[51] gnd reram_bitcell_7
Xbit_r52_c20 bl[20] br[20] wl[52] gnd reram_bitcell_7
Xbit_r53_c20 bl[20] br[20] wl[53] gnd reram_bitcell_7
Xbit_r54_c20 bl[20] br[20] wl[54] gnd reram_bitcell_7
Xbit_r55_c20 bl[20] br[20] wl[55] gnd reram_bitcell_7
Xbit_r56_c20 bl[20] br[20] wl[56] gnd reram_bitcell_7
Xbit_r57_c20 bl[20] br[20] wl[57] gnd reram_bitcell_7
Xbit_r58_c20 bl[20] br[20] wl[58] gnd reram_bitcell_7
Xbit_r59_c20 bl[20] br[20] wl[59] gnd reram_bitcell_7
Xbit_r60_c20 bl[20] br[20] wl[60] gnd reram_bitcell_7
Xbit_r61_c20 bl[20] br[20] wl[61] gnd reram_bitcell_7
Xbit_r62_c20 bl[20] br[20] wl[62] gnd reram_bitcell_7
Xbit_r63_c20 bl[20] br[20] wl[63] gnd reram_bitcell_7
Xbit_r0_c21 bl[21] br[21] wl[0] gnd reram_bitcell_7
Xbit_r1_c21 bl[21] br[21] wl[1] gnd reram_bitcell_7
Xbit_r2_c21 bl[21] br[21] wl[2] gnd reram_bitcell_7
Xbit_r3_c21 bl[21] br[21] wl[3] gnd reram_bitcell_7
Xbit_r4_c21 bl[21] br[21] wl[4] gnd reram_bitcell_7
Xbit_r5_c21 bl[21] br[21] wl[5] gnd reram_bitcell_7
Xbit_r6_c21 bl[21] br[21] wl[6] gnd reram_bitcell_7
Xbit_r7_c21 bl[21] br[21] wl[7] gnd reram_bitcell_7
Xbit_r8_c21 bl[21] br[21] wl[8] gnd reram_bitcell_7
Xbit_r9_c21 bl[21] br[21] wl[9] gnd reram_bitcell_7
Xbit_r10_c21 bl[21] br[21] wl[10] gnd reram_bitcell_7
Xbit_r11_c21 bl[21] br[21] wl[11] gnd reram_bitcell_7
Xbit_r12_c21 bl[21] br[21] wl[12] gnd reram_bitcell_7
Xbit_r13_c21 bl[21] br[21] wl[13] gnd reram_bitcell_7
Xbit_r14_c21 bl[21] br[21] wl[14] gnd reram_bitcell_7
Xbit_r15_c21 bl[21] br[21] wl[15] gnd reram_bitcell_7
Xbit_r16_c21 bl[21] br[21] wl[16] gnd reram_bitcell_7
Xbit_r17_c21 bl[21] br[21] wl[17] gnd reram_bitcell_7
Xbit_r18_c21 bl[21] br[21] wl[18] gnd reram_bitcell_7
Xbit_r19_c21 bl[21] br[21] wl[19] gnd reram_bitcell_7
Xbit_r20_c21 bl[21] br[21] wl[20] gnd reram_bitcell_7
Xbit_r21_c21 bl[21] br[21] wl[21] gnd reram_bitcell_7
Xbit_r22_c21 bl[21] br[21] wl[22] gnd reram_bitcell_7
Xbit_r23_c21 bl[21] br[21] wl[23] gnd reram_bitcell_7
Xbit_r24_c21 bl[21] br[21] wl[24] gnd reram_bitcell_7
Xbit_r25_c21 bl[21] br[21] wl[25] gnd reram_bitcell_7
Xbit_r26_c21 bl[21] br[21] wl[26] gnd reram_bitcell_7
Xbit_r27_c21 bl[21] br[21] wl[27] gnd reram_bitcell_7
Xbit_r28_c21 bl[21] br[21] wl[28] gnd reram_bitcell_7
Xbit_r29_c21 bl[21] br[21] wl[29] gnd reram_bitcell_7
Xbit_r30_c21 bl[21] br[21] wl[30] gnd reram_bitcell_7
Xbit_r31_c21 bl[21] br[21] wl[31] gnd reram_bitcell_7
Xbit_r32_c21 bl[21] br[21] wl[32] gnd reram_bitcell_7
Xbit_r33_c21 bl[21] br[21] wl[33] gnd reram_bitcell_7
Xbit_r34_c21 bl[21] br[21] wl[34] gnd reram_bitcell_7
Xbit_r35_c21 bl[21] br[21] wl[35] gnd reram_bitcell_7
Xbit_r36_c21 bl[21] br[21] wl[36] gnd reram_bitcell_7
Xbit_r37_c21 bl[21] br[21] wl[37] gnd reram_bitcell_7
Xbit_r38_c21 bl[21] br[21] wl[38] gnd reram_bitcell_7
Xbit_r39_c21 bl[21] br[21] wl[39] gnd reram_bitcell_7
Xbit_r40_c21 bl[21] br[21] wl[40] gnd reram_bitcell_7
Xbit_r41_c21 bl[21] br[21] wl[41] gnd reram_bitcell_7
Xbit_r42_c21 bl[21] br[21] wl[42] gnd reram_bitcell_7
Xbit_r43_c21 bl[21] br[21] wl[43] gnd reram_bitcell_7
Xbit_r44_c21 bl[21] br[21] wl[44] gnd reram_bitcell_7
Xbit_r45_c21 bl[21] br[21] wl[45] gnd reram_bitcell_7
Xbit_r46_c21 bl[21] br[21] wl[46] gnd reram_bitcell_7
Xbit_r47_c21 bl[21] br[21] wl[47] gnd reram_bitcell_7
Xbit_r48_c21 bl[21] br[21] wl[48] gnd reram_bitcell_7
Xbit_r49_c21 bl[21] br[21] wl[49] gnd reram_bitcell_7
Xbit_r50_c21 bl[21] br[21] wl[50] gnd reram_bitcell_7
Xbit_r51_c21 bl[21] br[21] wl[51] gnd reram_bitcell_7
Xbit_r52_c21 bl[21] br[21] wl[52] gnd reram_bitcell_7
Xbit_r53_c21 bl[21] br[21] wl[53] gnd reram_bitcell_7
Xbit_r54_c21 bl[21] br[21] wl[54] gnd reram_bitcell_7
Xbit_r55_c21 bl[21] br[21] wl[55] gnd reram_bitcell_7
Xbit_r56_c21 bl[21] br[21] wl[56] gnd reram_bitcell_7
Xbit_r57_c21 bl[21] br[21] wl[57] gnd reram_bitcell_7
Xbit_r58_c21 bl[21] br[21] wl[58] gnd reram_bitcell_7
Xbit_r59_c21 bl[21] br[21] wl[59] gnd reram_bitcell_7
Xbit_r60_c21 bl[21] br[21] wl[60] gnd reram_bitcell_7
Xbit_r61_c21 bl[21] br[21] wl[61] gnd reram_bitcell_7
Xbit_r62_c21 bl[21] br[21] wl[62] gnd reram_bitcell_7
Xbit_r63_c21 bl[21] br[21] wl[63] gnd reram_bitcell_7
Xbit_r0_c22 bl[22] br[22] wl[0] gnd reram_bitcell_7
Xbit_r1_c22 bl[22] br[22] wl[1] gnd reram_bitcell_7
Xbit_r2_c22 bl[22] br[22] wl[2] gnd reram_bitcell_7
Xbit_r3_c22 bl[22] br[22] wl[3] gnd reram_bitcell_7
Xbit_r4_c22 bl[22] br[22] wl[4] gnd reram_bitcell_7
Xbit_r5_c22 bl[22] br[22] wl[5] gnd reram_bitcell_7
Xbit_r6_c22 bl[22] br[22] wl[6] gnd reram_bitcell_7
Xbit_r7_c22 bl[22] br[22] wl[7] gnd reram_bitcell_7
Xbit_r8_c22 bl[22] br[22] wl[8] gnd reram_bitcell_7
Xbit_r9_c22 bl[22] br[22] wl[9] gnd reram_bitcell_7
Xbit_r10_c22 bl[22] br[22] wl[10] gnd reram_bitcell_7
Xbit_r11_c22 bl[22] br[22] wl[11] gnd reram_bitcell_7
Xbit_r12_c22 bl[22] br[22] wl[12] gnd reram_bitcell_7
Xbit_r13_c22 bl[22] br[22] wl[13] gnd reram_bitcell_7
Xbit_r14_c22 bl[22] br[22] wl[14] gnd reram_bitcell_7
Xbit_r15_c22 bl[22] br[22] wl[15] gnd reram_bitcell_7
Xbit_r16_c22 bl[22] br[22] wl[16] gnd reram_bitcell_7
Xbit_r17_c22 bl[22] br[22] wl[17] gnd reram_bitcell_7
Xbit_r18_c22 bl[22] br[22] wl[18] gnd reram_bitcell_7
Xbit_r19_c22 bl[22] br[22] wl[19] gnd reram_bitcell_7
Xbit_r20_c22 bl[22] br[22] wl[20] gnd reram_bitcell_7
Xbit_r21_c22 bl[22] br[22] wl[21] gnd reram_bitcell_7
Xbit_r22_c22 bl[22] br[22] wl[22] gnd reram_bitcell_7
Xbit_r23_c22 bl[22] br[22] wl[23] gnd reram_bitcell_7
Xbit_r24_c22 bl[22] br[22] wl[24] gnd reram_bitcell_7
Xbit_r25_c22 bl[22] br[22] wl[25] gnd reram_bitcell_7
Xbit_r26_c22 bl[22] br[22] wl[26] gnd reram_bitcell_7
Xbit_r27_c22 bl[22] br[22] wl[27] gnd reram_bitcell_7
Xbit_r28_c22 bl[22] br[22] wl[28] gnd reram_bitcell_7
Xbit_r29_c22 bl[22] br[22] wl[29] gnd reram_bitcell_7
Xbit_r30_c22 bl[22] br[22] wl[30] gnd reram_bitcell_7
Xbit_r31_c22 bl[22] br[22] wl[31] gnd reram_bitcell_7
Xbit_r32_c22 bl[22] br[22] wl[32] gnd reram_bitcell_7
Xbit_r33_c22 bl[22] br[22] wl[33] gnd reram_bitcell_7
Xbit_r34_c22 bl[22] br[22] wl[34] gnd reram_bitcell_7
Xbit_r35_c22 bl[22] br[22] wl[35] gnd reram_bitcell_7
Xbit_r36_c22 bl[22] br[22] wl[36] gnd reram_bitcell_7
Xbit_r37_c22 bl[22] br[22] wl[37] gnd reram_bitcell_7
Xbit_r38_c22 bl[22] br[22] wl[38] gnd reram_bitcell_7
Xbit_r39_c22 bl[22] br[22] wl[39] gnd reram_bitcell_7
Xbit_r40_c22 bl[22] br[22] wl[40] gnd reram_bitcell_7
Xbit_r41_c22 bl[22] br[22] wl[41] gnd reram_bitcell_7
Xbit_r42_c22 bl[22] br[22] wl[42] gnd reram_bitcell_7
Xbit_r43_c22 bl[22] br[22] wl[43] gnd reram_bitcell_7
Xbit_r44_c22 bl[22] br[22] wl[44] gnd reram_bitcell_7
Xbit_r45_c22 bl[22] br[22] wl[45] gnd reram_bitcell_7
Xbit_r46_c22 bl[22] br[22] wl[46] gnd reram_bitcell_7
Xbit_r47_c22 bl[22] br[22] wl[47] gnd reram_bitcell_7
Xbit_r48_c22 bl[22] br[22] wl[48] gnd reram_bitcell_7
Xbit_r49_c22 bl[22] br[22] wl[49] gnd reram_bitcell_7
Xbit_r50_c22 bl[22] br[22] wl[50] gnd reram_bitcell_7
Xbit_r51_c22 bl[22] br[22] wl[51] gnd reram_bitcell_7
Xbit_r52_c22 bl[22] br[22] wl[52] gnd reram_bitcell_7
Xbit_r53_c22 bl[22] br[22] wl[53] gnd reram_bitcell_7
Xbit_r54_c22 bl[22] br[22] wl[54] gnd reram_bitcell_7
Xbit_r55_c22 bl[22] br[22] wl[55] gnd reram_bitcell_7
Xbit_r56_c22 bl[22] br[22] wl[56] gnd reram_bitcell_7
Xbit_r57_c22 bl[22] br[22] wl[57] gnd reram_bitcell_7
Xbit_r58_c22 bl[22] br[22] wl[58] gnd reram_bitcell_7
Xbit_r59_c22 bl[22] br[22] wl[59] gnd reram_bitcell_7
Xbit_r60_c22 bl[22] br[22] wl[60] gnd reram_bitcell_7
Xbit_r61_c22 bl[22] br[22] wl[61] gnd reram_bitcell_7
Xbit_r62_c22 bl[22] br[22] wl[62] gnd reram_bitcell_7
Xbit_r63_c22 bl[22] br[22] wl[63] gnd reram_bitcell_7
Xbit_r0_c23 bl[23] br[23] wl[0] gnd reram_bitcell_7
Xbit_r1_c23 bl[23] br[23] wl[1] gnd reram_bitcell_7
Xbit_r2_c23 bl[23] br[23] wl[2] gnd reram_bitcell_7
Xbit_r3_c23 bl[23] br[23] wl[3] gnd reram_bitcell_7
Xbit_r4_c23 bl[23] br[23] wl[4] gnd reram_bitcell_7
Xbit_r5_c23 bl[23] br[23] wl[5] gnd reram_bitcell_7
Xbit_r6_c23 bl[23] br[23] wl[6] gnd reram_bitcell_7
Xbit_r7_c23 bl[23] br[23] wl[7] gnd reram_bitcell_7
Xbit_r8_c23 bl[23] br[23] wl[8] gnd reram_bitcell_7
Xbit_r9_c23 bl[23] br[23] wl[9] gnd reram_bitcell_7
Xbit_r10_c23 bl[23] br[23] wl[10] gnd reram_bitcell_7
Xbit_r11_c23 bl[23] br[23] wl[11] gnd reram_bitcell_7
Xbit_r12_c23 bl[23] br[23] wl[12] gnd reram_bitcell_7
Xbit_r13_c23 bl[23] br[23] wl[13] gnd reram_bitcell_7
Xbit_r14_c23 bl[23] br[23] wl[14] gnd reram_bitcell_7
Xbit_r15_c23 bl[23] br[23] wl[15] gnd reram_bitcell_7
Xbit_r16_c23 bl[23] br[23] wl[16] gnd reram_bitcell_7
Xbit_r17_c23 bl[23] br[23] wl[17] gnd reram_bitcell_7
Xbit_r18_c23 bl[23] br[23] wl[18] gnd reram_bitcell_7
Xbit_r19_c23 bl[23] br[23] wl[19] gnd reram_bitcell_7
Xbit_r20_c23 bl[23] br[23] wl[20] gnd reram_bitcell_7
Xbit_r21_c23 bl[23] br[23] wl[21] gnd reram_bitcell_7
Xbit_r22_c23 bl[23] br[23] wl[22] gnd reram_bitcell_7
Xbit_r23_c23 bl[23] br[23] wl[23] gnd reram_bitcell_7
Xbit_r24_c23 bl[23] br[23] wl[24] gnd reram_bitcell_7
Xbit_r25_c23 bl[23] br[23] wl[25] gnd reram_bitcell_7
Xbit_r26_c23 bl[23] br[23] wl[26] gnd reram_bitcell_7
Xbit_r27_c23 bl[23] br[23] wl[27] gnd reram_bitcell_7
Xbit_r28_c23 bl[23] br[23] wl[28] gnd reram_bitcell_7
Xbit_r29_c23 bl[23] br[23] wl[29] gnd reram_bitcell_7
Xbit_r30_c23 bl[23] br[23] wl[30] gnd reram_bitcell_7
Xbit_r31_c23 bl[23] br[23] wl[31] gnd reram_bitcell_7
Xbit_r32_c23 bl[23] br[23] wl[32] gnd reram_bitcell_7
Xbit_r33_c23 bl[23] br[23] wl[33] gnd reram_bitcell_7
Xbit_r34_c23 bl[23] br[23] wl[34] gnd reram_bitcell_7
Xbit_r35_c23 bl[23] br[23] wl[35] gnd reram_bitcell_7
Xbit_r36_c23 bl[23] br[23] wl[36] gnd reram_bitcell_7
Xbit_r37_c23 bl[23] br[23] wl[37] gnd reram_bitcell_7
Xbit_r38_c23 bl[23] br[23] wl[38] gnd reram_bitcell_7
Xbit_r39_c23 bl[23] br[23] wl[39] gnd reram_bitcell_7
Xbit_r40_c23 bl[23] br[23] wl[40] gnd reram_bitcell_7
Xbit_r41_c23 bl[23] br[23] wl[41] gnd reram_bitcell_7
Xbit_r42_c23 bl[23] br[23] wl[42] gnd reram_bitcell_7
Xbit_r43_c23 bl[23] br[23] wl[43] gnd reram_bitcell_7
Xbit_r44_c23 bl[23] br[23] wl[44] gnd reram_bitcell_7
Xbit_r45_c23 bl[23] br[23] wl[45] gnd reram_bitcell_7
Xbit_r46_c23 bl[23] br[23] wl[46] gnd reram_bitcell_7
Xbit_r47_c23 bl[23] br[23] wl[47] gnd reram_bitcell_7
Xbit_r48_c23 bl[23] br[23] wl[48] gnd reram_bitcell_7
Xbit_r49_c23 bl[23] br[23] wl[49] gnd reram_bitcell_7
Xbit_r50_c23 bl[23] br[23] wl[50] gnd reram_bitcell_7
Xbit_r51_c23 bl[23] br[23] wl[51] gnd reram_bitcell_7
Xbit_r52_c23 bl[23] br[23] wl[52] gnd reram_bitcell_7
Xbit_r53_c23 bl[23] br[23] wl[53] gnd reram_bitcell_7
Xbit_r54_c23 bl[23] br[23] wl[54] gnd reram_bitcell_7
Xbit_r55_c23 bl[23] br[23] wl[55] gnd reram_bitcell_7
Xbit_r56_c23 bl[23] br[23] wl[56] gnd reram_bitcell_7
Xbit_r57_c23 bl[23] br[23] wl[57] gnd reram_bitcell_7
Xbit_r58_c23 bl[23] br[23] wl[58] gnd reram_bitcell_7
Xbit_r59_c23 bl[23] br[23] wl[59] gnd reram_bitcell_7
Xbit_r60_c23 bl[23] br[23] wl[60] gnd reram_bitcell_7
Xbit_r61_c23 bl[23] br[23] wl[61] gnd reram_bitcell_7
Xbit_r62_c23 bl[23] br[23] wl[62] gnd reram_bitcell_7
Xbit_r63_c23 bl[23] br[23] wl[63] gnd reram_bitcell_7
Xbit_r0_c24 bl[24] br[24] wl[0] gnd reram_bitcell_7
Xbit_r1_c24 bl[24] br[24] wl[1] gnd reram_bitcell_7
Xbit_r2_c24 bl[24] br[24] wl[2] gnd reram_bitcell_7
Xbit_r3_c24 bl[24] br[24] wl[3] gnd reram_bitcell_7
Xbit_r4_c24 bl[24] br[24] wl[4] gnd reram_bitcell_7
Xbit_r5_c24 bl[24] br[24] wl[5] gnd reram_bitcell_7
Xbit_r6_c24 bl[24] br[24] wl[6] gnd reram_bitcell_7
Xbit_r7_c24 bl[24] br[24] wl[7] gnd reram_bitcell_7
Xbit_r8_c24 bl[24] br[24] wl[8] gnd reram_bitcell_7
Xbit_r9_c24 bl[24] br[24] wl[9] gnd reram_bitcell_7
Xbit_r10_c24 bl[24] br[24] wl[10] gnd reram_bitcell_7
Xbit_r11_c24 bl[24] br[24] wl[11] gnd reram_bitcell_7
Xbit_r12_c24 bl[24] br[24] wl[12] gnd reram_bitcell_7
Xbit_r13_c24 bl[24] br[24] wl[13] gnd reram_bitcell_7
Xbit_r14_c24 bl[24] br[24] wl[14] gnd reram_bitcell_7
Xbit_r15_c24 bl[24] br[24] wl[15] gnd reram_bitcell_7
Xbit_r16_c24 bl[24] br[24] wl[16] gnd reram_bitcell_7
Xbit_r17_c24 bl[24] br[24] wl[17] gnd reram_bitcell_7
Xbit_r18_c24 bl[24] br[24] wl[18] gnd reram_bitcell_7
Xbit_r19_c24 bl[24] br[24] wl[19] gnd reram_bitcell_7
Xbit_r20_c24 bl[24] br[24] wl[20] gnd reram_bitcell_7
Xbit_r21_c24 bl[24] br[24] wl[21] gnd reram_bitcell_7
Xbit_r22_c24 bl[24] br[24] wl[22] gnd reram_bitcell_7
Xbit_r23_c24 bl[24] br[24] wl[23] gnd reram_bitcell_7
Xbit_r24_c24 bl[24] br[24] wl[24] gnd reram_bitcell_7
Xbit_r25_c24 bl[24] br[24] wl[25] gnd reram_bitcell_7
Xbit_r26_c24 bl[24] br[24] wl[26] gnd reram_bitcell_7
Xbit_r27_c24 bl[24] br[24] wl[27] gnd reram_bitcell_7
Xbit_r28_c24 bl[24] br[24] wl[28] gnd reram_bitcell_7
Xbit_r29_c24 bl[24] br[24] wl[29] gnd reram_bitcell_7
Xbit_r30_c24 bl[24] br[24] wl[30] gnd reram_bitcell_7
Xbit_r31_c24 bl[24] br[24] wl[31] gnd reram_bitcell_7
Xbit_r32_c24 bl[24] br[24] wl[32] gnd reram_bitcell_7
Xbit_r33_c24 bl[24] br[24] wl[33] gnd reram_bitcell_7
Xbit_r34_c24 bl[24] br[24] wl[34] gnd reram_bitcell_7
Xbit_r35_c24 bl[24] br[24] wl[35] gnd reram_bitcell_7
Xbit_r36_c24 bl[24] br[24] wl[36] gnd reram_bitcell_7
Xbit_r37_c24 bl[24] br[24] wl[37] gnd reram_bitcell_7
Xbit_r38_c24 bl[24] br[24] wl[38] gnd reram_bitcell_7
Xbit_r39_c24 bl[24] br[24] wl[39] gnd reram_bitcell_7
Xbit_r40_c24 bl[24] br[24] wl[40] gnd reram_bitcell_7
Xbit_r41_c24 bl[24] br[24] wl[41] gnd reram_bitcell_7
Xbit_r42_c24 bl[24] br[24] wl[42] gnd reram_bitcell_7
Xbit_r43_c24 bl[24] br[24] wl[43] gnd reram_bitcell_7
Xbit_r44_c24 bl[24] br[24] wl[44] gnd reram_bitcell_7
Xbit_r45_c24 bl[24] br[24] wl[45] gnd reram_bitcell_7
Xbit_r46_c24 bl[24] br[24] wl[46] gnd reram_bitcell_7
Xbit_r47_c24 bl[24] br[24] wl[47] gnd reram_bitcell_7
Xbit_r48_c24 bl[24] br[24] wl[48] gnd reram_bitcell_7
Xbit_r49_c24 bl[24] br[24] wl[49] gnd reram_bitcell_7
Xbit_r50_c24 bl[24] br[24] wl[50] gnd reram_bitcell_7
Xbit_r51_c24 bl[24] br[24] wl[51] gnd reram_bitcell_7
Xbit_r52_c24 bl[24] br[24] wl[52] gnd reram_bitcell_7
Xbit_r53_c24 bl[24] br[24] wl[53] gnd reram_bitcell_7
Xbit_r54_c24 bl[24] br[24] wl[54] gnd reram_bitcell_7
Xbit_r55_c24 bl[24] br[24] wl[55] gnd reram_bitcell_7
Xbit_r56_c24 bl[24] br[24] wl[56] gnd reram_bitcell_7
Xbit_r57_c24 bl[24] br[24] wl[57] gnd reram_bitcell_7
Xbit_r58_c24 bl[24] br[24] wl[58] gnd reram_bitcell_7
Xbit_r59_c24 bl[24] br[24] wl[59] gnd reram_bitcell_7
Xbit_r60_c24 bl[24] br[24] wl[60] gnd reram_bitcell_7
Xbit_r61_c24 bl[24] br[24] wl[61] gnd reram_bitcell_7
Xbit_r62_c24 bl[24] br[24] wl[62] gnd reram_bitcell_7
Xbit_r63_c24 bl[24] br[24] wl[63] gnd reram_bitcell_7
Xbit_r0_c25 bl[25] br[25] wl[0] gnd reram_bitcell_7
Xbit_r1_c25 bl[25] br[25] wl[1] gnd reram_bitcell_7
Xbit_r2_c25 bl[25] br[25] wl[2] gnd reram_bitcell_7
Xbit_r3_c25 bl[25] br[25] wl[3] gnd reram_bitcell_7
Xbit_r4_c25 bl[25] br[25] wl[4] gnd reram_bitcell_7
Xbit_r5_c25 bl[25] br[25] wl[5] gnd reram_bitcell_7
Xbit_r6_c25 bl[25] br[25] wl[6] gnd reram_bitcell_7
Xbit_r7_c25 bl[25] br[25] wl[7] gnd reram_bitcell_7
Xbit_r8_c25 bl[25] br[25] wl[8] gnd reram_bitcell_7
Xbit_r9_c25 bl[25] br[25] wl[9] gnd reram_bitcell_7
Xbit_r10_c25 bl[25] br[25] wl[10] gnd reram_bitcell_7
Xbit_r11_c25 bl[25] br[25] wl[11] gnd reram_bitcell_7
Xbit_r12_c25 bl[25] br[25] wl[12] gnd reram_bitcell_7
Xbit_r13_c25 bl[25] br[25] wl[13] gnd reram_bitcell_7
Xbit_r14_c25 bl[25] br[25] wl[14] gnd reram_bitcell_7
Xbit_r15_c25 bl[25] br[25] wl[15] gnd reram_bitcell_7
Xbit_r16_c25 bl[25] br[25] wl[16] gnd reram_bitcell_7
Xbit_r17_c25 bl[25] br[25] wl[17] gnd reram_bitcell_7
Xbit_r18_c25 bl[25] br[25] wl[18] gnd reram_bitcell_7
Xbit_r19_c25 bl[25] br[25] wl[19] gnd reram_bitcell_7
Xbit_r20_c25 bl[25] br[25] wl[20] gnd reram_bitcell_7
Xbit_r21_c25 bl[25] br[25] wl[21] gnd reram_bitcell_7
Xbit_r22_c25 bl[25] br[25] wl[22] gnd reram_bitcell_7
Xbit_r23_c25 bl[25] br[25] wl[23] gnd reram_bitcell_7
Xbit_r24_c25 bl[25] br[25] wl[24] gnd reram_bitcell_7
Xbit_r25_c25 bl[25] br[25] wl[25] gnd reram_bitcell_7
Xbit_r26_c25 bl[25] br[25] wl[26] gnd reram_bitcell_7
Xbit_r27_c25 bl[25] br[25] wl[27] gnd reram_bitcell_7
Xbit_r28_c25 bl[25] br[25] wl[28] gnd reram_bitcell_7
Xbit_r29_c25 bl[25] br[25] wl[29] gnd reram_bitcell_7
Xbit_r30_c25 bl[25] br[25] wl[30] gnd reram_bitcell_7
Xbit_r31_c25 bl[25] br[25] wl[31] gnd reram_bitcell_7
Xbit_r32_c25 bl[25] br[25] wl[32] gnd reram_bitcell_7
Xbit_r33_c25 bl[25] br[25] wl[33] gnd reram_bitcell_7
Xbit_r34_c25 bl[25] br[25] wl[34] gnd reram_bitcell_7
Xbit_r35_c25 bl[25] br[25] wl[35] gnd reram_bitcell_7
Xbit_r36_c25 bl[25] br[25] wl[36] gnd reram_bitcell_7
Xbit_r37_c25 bl[25] br[25] wl[37] gnd reram_bitcell_7
Xbit_r38_c25 bl[25] br[25] wl[38] gnd reram_bitcell_7
Xbit_r39_c25 bl[25] br[25] wl[39] gnd reram_bitcell_7
Xbit_r40_c25 bl[25] br[25] wl[40] gnd reram_bitcell_7
Xbit_r41_c25 bl[25] br[25] wl[41] gnd reram_bitcell_7
Xbit_r42_c25 bl[25] br[25] wl[42] gnd reram_bitcell_7
Xbit_r43_c25 bl[25] br[25] wl[43] gnd reram_bitcell_7
Xbit_r44_c25 bl[25] br[25] wl[44] gnd reram_bitcell_7
Xbit_r45_c25 bl[25] br[25] wl[45] gnd reram_bitcell_7
Xbit_r46_c25 bl[25] br[25] wl[46] gnd reram_bitcell_7
Xbit_r47_c25 bl[25] br[25] wl[47] gnd reram_bitcell_7
Xbit_r48_c25 bl[25] br[25] wl[48] gnd reram_bitcell_7
Xbit_r49_c25 bl[25] br[25] wl[49] gnd reram_bitcell_7
Xbit_r50_c25 bl[25] br[25] wl[50] gnd reram_bitcell_7
Xbit_r51_c25 bl[25] br[25] wl[51] gnd reram_bitcell_7
Xbit_r52_c25 bl[25] br[25] wl[52] gnd reram_bitcell_7
Xbit_r53_c25 bl[25] br[25] wl[53] gnd reram_bitcell_7
Xbit_r54_c25 bl[25] br[25] wl[54] gnd reram_bitcell_7
Xbit_r55_c25 bl[25] br[25] wl[55] gnd reram_bitcell_7
Xbit_r56_c25 bl[25] br[25] wl[56] gnd reram_bitcell_7
Xbit_r57_c25 bl[25] br[25] wl[57] gnd reram_bitcell_7
Xbit_r58_c25 bl[25] br[25] wl[58] gnd reram_bitcell_7
Xbit_r59_c25 bl[25] br[25] wl[59] gnd reram_bitcell_7
Xbit_r60_c25 bl[25] br[25] wl[60] gnd reram_bitcell_7
Xbit_r61_c25 bl[25] br[25] wl[61] gnd reram_bitcell_7
Xbit_r62_c25 bl[25] br[25] wl[62] gnd reram_bitcell_7
Xbit_r63_c25 bl[25] br[25] wl[63] gnd reram_bitcell_7
Xbit_r0_c26 bl[26] br[26] wl[0] gnd reram_bitcell_7
Xbit_r1_c26 bl[26] br[26] wl[1] gnd reram_bitcell_7
Xbit_r2_c26 bl[26] br[26] wl[2] gnd reram_bitcell_7
Xbit_r3_c26 bl[26] br[26] wl[3] gnd reram_bitcell_7
Xbit_r4_c26 bl[26] br[26] wl[4] gnd reram_bitcell_7
Xbit_r5_c26 bl[26] br[26] wl[5] gnd reram_bitcell_7
Xbit_r6_c26 bl[26] br[26] wl[6] gnd reram_bitcell_7
Xbit_r7_c26 bl[26] br[26] wl[7] gnd reram_bitcell_7
Xbit_r8_c26 bl[26] br[26] wl[8] gnd reram_bitcell_7
Xbit_r9_c26 bl[26] br[26] wl[9] gnd reram_bitcell_7
Xbit_r10_c26 bl[26] br[26] wl[10] gnd reram_bitcell_7
Xbit_r11_c26 bl[26] br[26] wl[11] gnd reram_bitcell_7
Xbit_r12_c26 bl[26] br[26] wl[12] gnd reram_bitcell_7
Xbit_r13_c26 bl[26] br[26] wl[13] gnd reram_bitcell_7
Xbit_r14_c26 bl[26] br[26] wl[14] gnd reram_bitcell_7
Xbit_r15_c26 bl[26] br[26] wl[15] gnd reram_bitcell_7
Xbit_r16_c26 bl[26] br[26] wl[16] gnd reram_bitcell_7
Xbit_r17_c26 bl[26] br[26] wl[17] gnd reram_bitcell_7
Xbit_r18_c26 bl[26] br[26] wl[18] gnd reram_bitcell_7
Xbit_r19_c26 bl[26] br[26] wl[19] gnd reram_bitcell_7
Xbit_r20_c26 bl[26] br[26] wl[20] gnd reram_bitcell_7
Xbit_r21_c26 bl[26] br[26] wl[21] gnd reram_bitcell_7
Xbit_r22_c26 bl[26] br[26] wl[22] gnd reram_bitcell_7
Xbit_r23_c26 bl[26] br[26] wl[23] gnd reram_bitcell_7
Xbit_r24_c26 bl[26] br[26] wl[24] gnd reram_bitcell_7
Xbit_r25_c26 bl[26] br[26] wl[25] gnd reram_bitcell_7
Xbit_r26_c26 bl[26] br[26] wl[26] gnd reram_bitcell_7
Xbit_r27_c26 bl[26] br[26] wl[27] gnd reram_bitcell_7
Xbit_r28_c26 bl[26] br[26] wl[28] gnd reram_bitcell_7
Xbit_r29_c26 bl[26] br[26] wl[29] gnd reram_bitcell_7
Xbit_r30_c26 bl[26] br[26] wl[30] gnd reram_bitcell_7
Xbit_r31_c26 bl[26] br[26] wl[31] gnd reram_bitcell_7
Xbit_r32_c26 bl[26] br[26] wl[32] gnd reram_bitcell_7
Xbit_r33_c26 bl[26] br[26] wl[33] gnd reram_bitcell_7
Xbit_r34_c26 bl[26] br[26] wl[34] gnd reram_bitcell_7
Xbit_r35_c26 bl[26] br[26] wl[35] gnd reram_bitcell_7
Xbit_r36_c26 bl[26] br[26] wl[36] gnd reram_bitcell_7
Xbit_r37_c26 bl[26] br[26] wl[37] gnd reram_bitcell_7
Xbit_r38_c26 bl[26] br[26] wl[38] gnd reram_bitcell_7
Xbit_r39_c26 bl[26] br[26] wl[39] gnd reram_bitcell_7
Xbit_r40_c26 bl[26] br[26] wl[40] gnd reram_bitcell_7
Xbit_r41_c26 bl[26] br[26] wl[41] gnd reram_bitcell_7
Xbit_r42_c26 bl[26] br[26] wl[42] gnd reram_bitcell_7
Xbit_r43_c26 bl[26] br[26] wl[43] gnd reram_bitcell_7
Xbit_r44_c26 bl[26] br[26] wl[44] gnd reram_bitcell_7
Xbit_r45_c26 bl[26] br[26] wl[45] gnd reram_bitcell_7
Xbit_r46_c26 bl[26] br[26] wl[46] gnd reram_bitcell_7
Xbit_r47_c26 bl[26] br[26] wl[47] gnd reram_bitcell_7
Xbit_r48_c26 bl[26] br[26] wl[48] gnd reram_bitcell_7
Xbit_r49_c26 bl[26] br[26] wl[49] gnd reram_bitcell_7
Xbit_r50_c26 bl[26] br[26] wl[50] gnd reram_bitcell_7
Xbit_r51_c26 bl[26] br[26] wl[51] gnd reram_bitcell_7
Xbit_r52_c26 bl[26] br[26] wl[52] gnd reram_bitcell_7
Xbit_r53_c26 bl[26] br[26] wl[53] gnd reram_bitcell_7
Xbit_r54_c26 bl[26] br[26] wl[54] gnd reram_bitcell_7
Xbit_r55_c26 bl[26] br[26] wl[55] gnd reram_bitcell_7
Xbit_r56_c26 bl[26] br[26] wl[56] gnd reram_bitcell_7
Xbit_r57_c26 bl[26] br[26] wl[57] gnd reram_bitcell_7
Xbit_r58_c26 bl[26] br[26] wl[58] gnd reram_bitcell_7
Xbit_r59_c26 bl[26] br[26] wl[59] gnd reram_bitcell_7
Xbit_r60_c26 bl[26] br[26] wl[60] gnd reram_bitcell_7
Xbit_r61_c26 bl[26] br[26] wl[61] gnd reram_bitcell_7
Xbit_r62_c26 bl[26] br[26] wl[62] gnd reram_bitcell_7
Xbit_r63_c26 bl[26] br[26] wl[63] gnd reram_bitcell_7
Xbit_r0_c27 bl[27] br[27] wl[0] gnd reram_bitcell_7
Xbit_r1_c27 bl[27] br[27] wl[1] gnd reram_bitcell_7
Xbit_r2_c27 bl[27] br[27] wl[2] gnd reram_bitcell_7
Xbit_r3_c27 bl[27] br[27] wl[3] gnd reram_bitcell_7
Xbit_r4_c27 bl[27] br[27] wl[4] gnd reram_bitcell_7
Xbit_r5_c27 bl[27] br[27] wl[5] gnd reram_bitcell_7
Xbit_r6_c27 bl[27] br[27] wl[6] gnd reram_bitcell_7
Xbit_r7_c27 bl[27] br[27] wl[7] gnd reram_bitcell_7
Xbit_r8_c27 bl[27] br[27] wl[8] gnd reram_bitcell_7
Xbit_r9_c27 bl[27] br[27] wl[9] gnd reram_bitcell_7
Xbit_r10_c27 bl[27] br[27] wl[10] gnd reram_bitcell_7
Xbit_r11_c27 bl[27] br[27] wl[11] gnd reram_bitcell_7
Xbit_r12_c27 bl[27] br[27] wl[12] gnd reram_bitcell_7
Xbit_r13_c27 bl[27] br[27] wl[13] gnd reram_bitcell_7
Xbit_r14_c27 bl[27] br[27] wl[14] gnd reram_bitcell_7
Xbit_r15_c27 bl[27] br[27] wl[15] gnd reram_bitcell_7
Xbit_r16_c27 bl[27] br[27] wl[16] gnd reram_bitcell_7
Xbit_r17_c27 bl[27] br[27] wl[17] gnd reram_bitcell_7
Xbit_r18_c27 bl[27] br[27] wl[18] gnd reram_bitcell_7
Xbit_r19_c27 bl[27] br[27] wl[19] gnd reram_bitcell_7
Xbit_r20_c27 bl[27] br[27] wl[20] gnd reram_bitcell_7
Xbit_r21_c27 bl[27] br[27] wl[21] gnd reram_bitcell_7
Xbit_r22_c27 bl[27] br[27] wl[22] gnd reram_bitcell_7
Xbit_r23_c27 bl[27] br[27] wl[23] gnd reram_bitcell_7
Xbit_r24_c27 bl[27] br[27] wl[24] gnd reram_bitcell_7
Xbit_r25_c27 bl[27] br[27] wl[25] gnd reram_bitcell_7
Xbit_r26_c27 bl[27] br[27] wl[26] gnd reram_bitcell_7
Xbit_r27_c27 bl[27] br[27] wl[27] gnd reram_bitcell_7
Xbit_r28_c27 bl[27] br[27] wl[28] gnd reram_bitcell_7
Xbit_r29_c27 bl[27] br[27] wl[29] gnd reram_bitcell_7
Xbit_r30_c27 bl[27] br[27] wl[30] gnd reram_bitcell_7
Xbit_r31_c27 bl[27] br[27] wl[31] gnd reram_bitcell_7
Xbit_r32_c27 bl[27] br[27] wl[32] gnd reram_bitcell_7
Xbit_r33_c27 bl[27] br[27] wl[33] gnd reram_bitcell_7
Xbit_r34_c27 bl[27] br[27] wl[34] gnd reram_bitcell_7
Xbit_r35_c27 bl[27] br[27] wl[35] gnd reram_bitcell_7
Xbit_r36_c27 bl[27] br[27] wl[36] gnd reram_bitcell_7
Xbit_r37_c27 bl[27] br[27] wl[37] gnd reram_bitcell_7
Xbit_r38_c27 bl[27] br[27] wl[38] gnd reram_bitcell_7
Xbit_r39_c27 bl[27] br[27] wl[39] gnd reram_bitcell_7
Xbit_r40_c27 bl[27] br[27] wl[40] gnd reram_bitcell_7
Xbit_r41_c27 bl[27] br[27] wl[41] gnd reram_bitcell_7
Xbit_r42_c27 bl[27] br[27] wl[42] gnd reram_bitcell_7
Xbit_r43_c27 bl[27] br[27] wl[43] gnd reram_bitcell_7
Xbit_r44_c27 bl[27] br[27] wl[44] gnd reram_bitcell_7
Xbit_r45_c27 bl[27] br[27] wl[45] gnd reram_bitcell_7
Xbit_r46_c27 bl[27] br[27] wl[46] gnd reram_bitcell_7
Xbit_r47_c27 bl[27] br[27] wl[47] gnd reram_bitcell_7
Xbit_r48_c27 bl[27] br[27] wl[48] gnd reram_bitcell_7
Xbit_r49_c27 bl[27] br[27] wl[49] gnd reram_bitcell_7
Xbit_r50_c27 bl[27] br[27] wl[50] gnd reram_bitcell_7
Xbit_r51_c27 bl[27] br[27] wl[51] gnd reram_bitcell_7
Xbit_r52_c27 bl[27] br[27] wl[52] gnd reram_bitcell_7
Xbit_r53_c27 bl[27] br[27] wl[53] gnd reram_bitcell_7
Xbit_r54_c27 bl[27] br[27] wl[54] gnd reram_bitcell_7
Xbit_r55_c27 bl[27] br[27] wl[55] gnd reram_bitcell_7
Xbit_r56_c27 bl[27] br[27] wl[56] gnd reram_bitcell_7
Xbit_r57_c27 bl[27] br[27] wl[57] gnd reram_bitcell_7
Xbit_r58_c27 bl[27] br[27] wl[58] gnd reram_bitcell_7
Xbit_r59_c27 bl[27] br[27] wl[59] gnd reram_bitcell_7
Xbit_r60_c27 bl[27] br[27] wl[60] gnd reram_bitcell_7
Xbit_r61_c27 bl[27] br[27] wl[61] gnd reram_bitcell_7
Xbit_r62_c27 bl[27] br[27] wl[62] gnd reram_bitcell_7
Xbit_r63_c27 bl[27] br[27] wl[63] gnd reram_bitcell_7
Xbit_r0_c28 bl[28] br[28] wl[0] gnd reram_bitcell_7
Xbit_r1_c28 bl[28] br[28] wl[1] gnd reram_bitcell_7
Xbit_r2_c28 bl[28] br[28] wl[2] gnd reram_bitcell_7
Xbit_r3_c28 bl[28] br[28] wl[3] gnd reram_bitcell_7
Xbit_r4_c28 bl[28] br[28] wl[4] gnd reram_bitcell_7
Xbit_r5_c28 bl[28] br[28] wl[5] gnd reram_bitcell_7
Xbit_r6_c28 bl[28] br[28] wl[6] gnd reram_bitcell_7
Xbit_r7_c28 bl[28] br[28] wl[7] gnd reram_bitcell_7
Xbit_r8_c28 bl[28] br[28] wl[8] gnd reram_bitcell_7
Xbit_r9_c28 bl[28] br[28] wl[9] gnd reram_bitcell_7
Xbit_r10_c28 bl[28] br[28] wl[10] gnd reram_bitcell_7
Xbit_r11_c28 bl[28] br[28] wl[11] gnd reram_bitcell_7
Xbit_r12_c28 bl[28] br[28] wl[12] gnd reram_bitcell_7
Xbit_r13_c28 bl[28] br[28] wl[13] gnd reram_bitcell_7
Xbit_r14_c28 bl[28] br[28] wl[14] gnd reram_bitcell_7
Xbit_r15_c28 bl[28] br[28] wl[15] gnd reram_bitcell_7
Xbit_r16_c28 bl[28] br[28] wl[16] gnd reram_bitcell_7
Xbit_r17_c28 bl[28] br[28] wl[17] gnd reram_bitcell_7
Xbit_r18_c28 bl[28] br[28] wl[18] gnd reram_bitcell_7
Xbit_r19_c28 bl[28] br[28] wl[19] gnd reram_bitcell_7
Xbit_r20_c28 bl[28] br[28] wl[20] gnd reram_bitcell_7
Xbit_r21_c28 bl[28] br[28] wl[21] gnd reram_bitcell_7
Xbit_r22_c28 bl[28] br[28] wl[22] gnd reram_bitcell_7
Xbit_r23_c28 bl[28] br[28] wl[23] gnd reram_bitcell_7
Xbit_r24_c28 bl[28] br[28] wl[24] gnd reram_bitcell_7
Xbit_r25_c28 bl[28] br[28] wl[25] gnd reram_bitcell_7
Xbit_r26_c28 bl[28] br[28] wl[26] gnd reram_bitcell_7
Xbit_r27_c28 bl[28] br[28] wl[27] gnd reram_bitcell_7
Xbit_r28_c28 bl[28] br[28] wl[28] gnd reram_bitcell_7
Xbit_r29_c28 bl[28] br[28] wl[29] gnd reram_bitcell_7
Xbit_r30_c28 bl[28] br[28] wl[30] gnd reram_bitcell_7
Xbit_r31_c28 bl[28] br[28] wl[31] gnd reram_bitcell_7
Xbit_r32_c28 bl[28] br[28] wl[32] gnd reram_bitcell_7
Xbit_r33_c28 bl[28] br[28] wl[33] gnd reram_bitcell_7
Xbit_r34_c28 bl[28] br[28] wl[34] gnd reram_bitcell_7
Xbit_r35_c28 bl[28] br[28] wl[35] gnd reram_bitcell_7
Xbit_r36_c28 bl[28] br[28] wl[36] gnd reram_bitcell_7
Xbit_r37_c28 bl[28] br[28] wl[37] gnd reram_bitcell_7
Xbit_r38_c28 bl[28] br[28] wl[38] gnd reram_bitcell_7
Xbit_r39_c28 bl[28] br[28] wl[39] gnd reram_bitcell_7
Xbit_r40_c28 bl[28] br[28] wl[40] gnd reram_bitcell_7
Xbit_r41_c28 bl[28] br[28] wl[41] gnd reram_bitcell_7
Xbit_r42_c28 bl[28] br[28] wl[42] gnd reram_bitcell_7
Xbit_r43_c28 bl[28] br[28] wl[43] gnd reram_bitcell_7
Xbit_r44_c28 bl[28] br[28] wl[44] gnd reram_bitcell_7
Xbit_r45_c28 bl[28] br[28] wl[45] gnd reram_bitcell_7
Xbit_r46_c28 bl[28] br[28] wl[46] gnd reram_bitcell_7
Xbit_r47_c28 bl[28] br[28] wl[47] gnd reram_bitcell_7
Xbit_r48_c28 bl[28] br[28] wl[48] gnd reram_bitcell_7
Xbit_r49_c28 bl[28] br[28] wl[49] gnd reram_bitcell_7
Xbit_r50_c28 bl[28] br[28] wl[50] gnd reram_bitcell_7
Xbit_r51_c28 bl[28] br[28] wl[51] gnd reram_bitcell_7
Xbit_r52_c28 bl[28] br[28] wl[52] gnd reram_bitcell_7
Xbit_r53_c28 bl[28] br[28] wl[53] gnd reram_bitcell_7
Xbit_r54_c28 bl[28] br[28] wl[54] gnd reram_bitcell_7
Xbit_r55_c28 bl[28] br[28] wl[55] gnd reram_bitcell_7
Xbit_r56_c28 bl[28] br[28] wl[56] gnd reram_bitcell_7
Xbit_r57_c28 bl[28] br[28] wl[57] gnd reram_bitcell_7
Xbit_r58_c28 bl[28] br[28] wl[58] gnd reram_bitcell_7
Xbit_r59_c28 bl[28] br[28] wl[59] gnd reram_bitcell_7
Xbit_r60_c28 bl[28] br[28] wl[60] gnd reram_bitcell_7
Xbit_r61_c28 bl[28] br[28] wl[61] gnd reram_bitcell_7
Xbit_r62_c28 bl[28] br[28] wl[62] gnd reram_bitcell_7
Xbit_r63_c28 bl[28] br[28] wl[63] gnd reram_bitcell_7
Xbit_r0_c29 bl[29] br[29] wl[0] gnd reram_bitcell_7
Xbit_r1_c29 bl[29] br[29] wl[1] gnd reram_bitcell_7
Xbit_r2_c29 bl[29] br[29] wl[2] gnd reram_bitcell_7
Xbit_r3_c29 bl[29] br[29] wl[3] gnd reram_bitcell_7
Xbit_r4_c29 bl[29] br[29] wl[4] gnd reram_bitcell_7
Xbit_r5_c29 bl[29] br[29] wl[5] gnd reram_bitcell_7
Xbit_r6_c29 bl[29] br[29] wl[6] gnd reram_bitcell_7
Xbit_r7_c29 bl[29] br[29] wl[7] gnd reram_bitcell_7
Xbit_r8_c29 bl[29] br[29] wl[8] gnd reram_bitcell_7
Xbit_r9_c29 bl[29] br[29] wl[9] gnd reram_bitcell_7
Xbit_r10_c29 bl[29] br[29] wl[10] gnd reram_bitcell_7
Xbit_r11_c29 bl[29] br[29] wl[11] gnd reram_bitcell_7
Xbit_r12_c29 bl[29] br[29] wl[12] gnd reram_bitcell_7
Xbit_r13_c29 bl[29] br[29] wl[13] gnd reram_bitcell_7
Xbit_r14_c29 bl[29] br[29] wl[14] gnd reram_bitcell_7
Xbit_r15_c29 bl[29] br[29] wl[15] gnd reram_bitcell_7
Xbit_r16_c29 bl[29] br[29] wl[16] gnd reram_bitcell_7
Xbit_r17_c29 bl[29] br[29] wl[17] gnd reram_bitcell_7
Xbit_r18_c29 bl[29] br[29] wl[18] gnd reram_bitcell_7
Xbit_r19_c29 bl[29] br[29] wl[19] gnd reram_bitcell_7
Xbit_r20_c29 bl[29] br[29] wl[20] gnd reram_bitcell_7
Xbit_r21_c29 bl[29] br[29] wl[21] gnd reram_bitcell_7
Xbit_r22_c29 bl[29] br[29] wl[22] gnd reram_bitcell_7
Xbit_r23_c29 bl[29] br[29] wl[23] gnd reram_bitcell_7
Xbit_r24_c29 bl[29] br[29] wl[24] gnd reram_bitcell_7
Xbit_r25_c29 bl[29] br[29] wl[25] gnd reram_bitcell_7
Xbit_r26_c29 bl[29] br[29] wl[26] gnd reram_bitcell_7
Xbit_r27_c29 bl[29] br[29] wl[27] gnd reram_bitcell_7
Xbit_r28_c29 bl[29] br[29] wl[28] gnd reram_bitcell_7
Xbit_r29_c29 bl[29] br[29] wl[29] gnd reram_bitcell_7
Xbit_r30_c29 bl[29] br[29] wl[30] gnd reram_bitcell_7
Xbit_r31_c29 bl[29] br[29] wl[31] gnd reram_bitcell_7
Xbit_r32_c29 bl[29] br[29] wl[32] gnd reram_bitcell_7
Xbit_r33_c29 bl[29] br[29] wl[33] gnd reram_bitcell_7
Xbit_r34_c29 bl[29] br[29] wl[34] gnd reram_bitcell_7
Xbit_r35_c29 bl[29] br[29] wl[35] gnd reram_bitcell_7
Xbit_r36_c29 bl[29] br[29] wl[36] gnd reram_bitcell_7
Xbit_r37_c29 bl[29] br[29] wl[37] gnd reram_bitcell_7
Xbit_r38_c29 bl[29] br[29] wl[38] gnd reram_bitcell_7
Xbit_r39_c29 bl[29] br[29] wl[39] gnd reram_bitcell_7
Xbit_r40_c29 bl[29] br[29] wl[40] gnd reram_bitcell_7
Xbit_r41_c29 bl[29] br[29] wl[41] gnd reram_bitcell_7
Xbit_r42_c29 bl[29] br[29] wl[42] gnd reram_bitcell_7
Xbit_r43_c29 bl[29] br[29] wl[43] gnd reram_bitcell_7
Xbit_r44_c29 bl[29] br[29] wl[44] gnd reram_bitcell_7
Xbit_r45_c29 bl[29] br[29] wl[45] gnd reram_bitcell_7
Xbit_r46_c29 bl[29] br[29] wl[46] gnd reram_bitcell_7
Xbit_r47_c29 bl[29] br[29] wl[47] gnd reram_bitcell_7
Xbit_r48_c29 bl[29] br[29] wl[48] gnd reram_bitcell_7
Xbit_r49_c29 bl[29] br[29] wl[49] gnd reram_bitcell_7
Xbit_r50_c29 bl[29] br[29] wl[50] gnd reram_bitcell_7
Xbit_r51_c29 bl[29] br[29] wl[51] gnd reram_bitcell_7
Xbit_r52_c29 bl[29] br[29] wl[52] gnd reram_bitcell_7
Xbit_r53_c29 bl[29] br[29] wl[53] gnd reram_bitcell_7
Xbit_r54_c29 bl[29] br[29] wl[54] gnd reram_bitcell_7
Xbit_r55_c29 bl[29] br[29] wl[55] gnd reram_bitcell_7
Xbit_r56_c29 bl[29] br[29] wl[56] gnd reram_bitcell_7
Xbit_r57_c29 bl[29] br[29] wl[57] gnd reram_bitcell_7
Xbit_r58_c29 bl[29] br[29] wl[58] gnd reram_bitcell_7
Xbit_r59_c29 bl[29] br[29] wl[59] gnd reram_bitcell_7
Xbit_r60_c29 bl[29] br[29] wl[60] gnd reram_bitcell_7
Xbit_r61_c29 bl[29] br[29] wl[61] gnd reram_bitcell_7
Xbit_r62_c29 bl[29] br[29] wl[62] gnd reram_bitcell_7
Xbit_r63_c29 bl[29] br[29] wl[63] gnd reram_bitcell_7
Xbit_r0_c30 bl[30] br[30] wl[0] gnd reram_bitcell_7
Xbit_r1_c30 bl[30] br[30] wl[1] gnd reram_bitcell_7
Xbit_r2_c30 bl[30] br[30] wl[2] gnd reram_bitcell_7
Xbit_r3_c30 bl[30] br[30] wl[3] gnd reram_bitcell_7
Xbit_r4_c30 bl[30] br[30] wl[4] gnd reram_bitcell_7
Xbit_r5_c30 bl[30] br[30] wl[5] gnd reram_bitcell_7
Xbit_r6_c30 bl[30] br[30] wl[6] gnd reram_bitcell_7
Xbit_r7_c30 bl[30] br[30] wl[7] gnd reram_bitcell_7
Xbit_r8_c30 bl[30] br[30] wl[8] gnd reram_bitcell_7
Xbit_r9_c30 bl[30] br[30] wl[9] gnd reram_bitcell_7
Xbit_r10_c30 bl[30] br[30] wl[10] gnd reram_bitcell_7
Xbit_r11_c30 bl[30] br[30] wl[11] gnd reram_bitcell_7
Xbit_r12_c30 bl[30] br[30] wl[12] gnd reram_bitcell_7
Xbit_r13_c30 bl[30] br[30] wl[13] gnd reram_bitcell_7
Xbit_r14_c30 bl[30] br[30] wl[14] gnd reram_bitcell_7
Xbit_r15_c30 bl[30] br[30] wl[15] gnd reram_bitcell_7
Xbit_r16_c30 bl[30] br[30] wl[16] gnd reram_bitcell_7
Xbit_r17_c30 bl[30] br[30] wl[17] gnd reram_bitcell_7
Xbit_r18_c30 bl[30] br[30] wl[18] gnd reram_bitcell_7
Xbit_r19_c30 bl[30] br[30] wl[19] gnd reram_bitcell_7
Xbit_r20_c30 bl[30] br[30] wl[20] gnd reram_bitcell_7
Xbit_r21_c30 bl[30] br[30] wl[21] gnd reram_bitcell_7
Xbit_r22_c30 bl[30] br[30] wl[22] gnd reram_bitcell_7
Xbit_r23_c30 bl[30] br[30] wl[23] gnd reram_bitcell_7
Xbit_r24_c30 bl[30] br[30] wl[24] gnd reram_bitcell_7
Xbit_r25_c30 bl[30] br[30] wl[25] gnd reram_bitcell_7
Xbit_r26_c30 bl[30] br[30] wl[26] gnd reram_bitcell_7
Xbit_r27_c30 bl[30] br[30] wl[27] gnd reram_bitcell_7
Xbit_r28_c30 bl[30] br[30] wl[28] gnd reram_bitcell_7
Xbit_r29_c30 bl[30] br[30] wl[29] gnd reram_bitcell_7
Xbit_r30_c30 bl[30] br[30] wl[30] gnd reram_bitcell_7
Xbit_r31_c30 bl[30] br[30] wl[31] gnd reram_bitcell_7
Xbit_r32_c30 bl[30] br[30] wl[32] gnd reram_bitcell_7
Xbit_r33_c30 bl[30] br[30] wl[33] gnd reram_bitcell_7
Xbit_r34_c30 bl[30] br[30] wl[34] gnd reram_bitcell_7
Xbit_r35_c30 bl[30] br[30] wl[35] gnd reram_bitcell_7
Xbit_r36_c30 bl[30] br[30] wl[36] gnd reram_bitcell_7
Xbit_r37_c30 bl[30] br[30] wl[37] gnd reram_bitcell_7
Xbit_r38_c30 bl[30] br[30] wl[38] gnd reram_bitcell_7
Xbit_r39_c30 bl[30] br[30] wl[39] gnd reram_bitcell_7
Xbit_r40_c30 bl[30] br[30] wl[40] gnd reram_bitcell_7
Xbit_r41_c30 bl[30] br[30] wl[41] gnd reram_bitcell_7
Xbit_r42_c30 bl[30] br[30] wl[42] gnd reram_bitcell_7
Xbit_r43_c30 bl[30] br[30] wl[43] gnd reram_bitcell_7
Xbit_r44_c30 bl[30] br[30] wl[44] gnd reram_bitcell_7
Xbit_r45_c30 bl[30] br[30] wl[45] gnd reram_bitcell_7
Xbit_r46_c30 bl[30] br[30] wl[46] gnd reram_bitcell_7
Xbit_r47_c30 bl[30] br[30] wl[47] gnd reram_bitcell_7
Xbit_r48_c30 bl[30] br[30] wl[48] gnd reram_bitcell_7
Xbit_r49_c30 bl[30] br[30] wl[49] gnd reram_bitcell_7
Xbit_r50_c30 bl[30] br[30] wl[50] gnd reram_bitcell_7
Xbit_r51_c30 bl[30] br[30] wl[51] gnd reram_bitcell_7
Xbit_r52_c30 bl[30] br[30] wl[52] gnd reram_bitcell_7
Xbit_r53_c30 bl[30] br[30] wl[53] gnd reram_bitcell_7
Xbit_r54_c30 bl[30] br[30] wl[54] gnd reram_bitcell_7
Xbit_r55_c30 bl[30] br[30] wl[55] gnd reram_bitcell_7
Xbit_r56_c30 bl[30] br[30] wl[56] gnd reram_bitcell_7
Xbit_r57_c30 bl[30] br[30] wl[57] gnd reram_bitcell_7
Xbit_r58_c30 bl[30] br[30] wl[58] gnd reram_bitcell_7
Xbit_r59_c30 bl[30] br[30] wl[59] gnd reram_bitcell_7
Xbit_r60_c30 bl[30] br[30] wl[60] gnd reram_bitcell_7
Xbit_r61_c30 bl[30] br[30] wl[61] gnd reram_bitcell_7
Xbit_r62_c30 bl[30] br[30] wl[62] gnd reram_bitcell_7
Xbit_r63_c30 bl[30] br[30] wl[63] gnd reram_bitcell_7
Xbit_r0_c31 bl[31] br[31] wl[0] gnd reram_bitcell_7
Xbit_r1_c31 bl[31] br[31] wl[1] gnd reram_bitcell_7
Xbit_r2_c31 bl[31] br[31] wl[2] gnd reram_bitcell_7
Xbit_r3_c31 bl[31] br[31] wl[3] gnd reram_bitcell_7
Xbit_r4_c31 bl[31] br[31] wl[4] gnd reram_bitcell_7
Xbit_r5_c31 bl[31] br[31] wl[5] gnd reram_bitcell_7
Xbit_r6_c31 bl[31] br[31] wl[6] gnd reram_bitcell_7
Xbit_r7_c31 bl[31] br[31] wl[7] gnd reram_bitcell_7
Xbit_r8_c31 bl[31] br[31] wl[8] gnd reram_bitcell_7
Xbit_r9_c31 bl[31] br[31] wl[9] gnd reram_bitcell_7
Xbit_r10_c31 bl[31] br[31] wl[10] gnd reram_bitcell_7
Xbit_r11_c31 bl[31] br[31] wl[11] gnd reram_bitcell_7
Xbit_r12_c31 bl[31] br[31] wl[12] gnd reram_bitcell_7
Xbit_r13_c31 bl[31] br[31] wl[13] gnd reram_bitcell_7
Xbit_r14_c31 bl[31] br[31] wl[14] gnd reram_bitcell_7
Xbit_r15_c31 bl[31] br[31] wl[15] gnd reram_bitcell_7
Xbit_r16_c31 bl[31] br[31] wl[16] gnd reram_bitcell_7
Xbit_r17_c31 bl[31] br[31] wl[17] gnd reram_bitcell_7
Xbit_r18_c31 bl[31] br[31] wl[18] gnd reram_bitcell_7
Xbit_r19_c31 bl[31] br[31] wl[19] gnd reram_bitcell_7
Xbit_r20_c31 bl[31] br[31] wl[20] gnd reram_bitcell_7
Xbit_r21_c31 bl[31] br[31] wl[21] gnd reram_bitcell_7
Xbit_r22_c31 bl[31] br[31] wl[22] gnd reram_bitcell_7
Xbit_r23_c31 bl[31] br[31] wl[23] gnd reram_bitcell_7
Xbit_r24_c31 bl[31] br[31] wl[24] gnd reram_bitcell_7
Xbit_r25_c31 bl[31] br[31] wl[25] gnd reram_bitcell_7
Xbit_r26_c31 bl[31] br[31] wl[26] gnd reram_bitcell_7
Xbit_r27_c31 bl[31] br[31] wl[27] gnd reram_bitcell_7
Xbit_r28_c31 bl[31] br[31] wl[28] gnd reram_bitcell_7
Xbit_r29_c31 bl[31] br[31] wl[29] gnd reram_bitcell_7
Xbit_r30_c31 bl[31] br[31] wl[30] gnd reram_bitcell_7
Xbit_r31_c31 bl[31] br[31] wl[31] gnd reram_bitcell_7
Xbit_r32_c31 bl[31] br[31] wl[32] gnd reram_bitcell_7
Xbit_r33_c31 bl[31] br[31] wl[33] gnd reram_bitcell_7
Xbit_r34_c31 bl[31] br[31] wl[34] gnd reram_bitcell_7
Xbit_r35_c31 bl[31] br[31] wl[35] gnd reram_bitcell_7
Xbit_r36_c31 bl[31] br[31] wl[36] gnd reram_bitcell_7
Xbit_r37_c31 bl[31] br[31] wl[37] gnd reram_bitcell_7
Xbit_r38_c31 bl[31] br[31] wl[38] gnd reram_bitcell_7
Xbit_r39_c31 bl[31] br[31] wl[39] gnd reram_bitcell_7
Xbit_r40_c31 bl[31] br[31] wl[40] gnd reram_bitcell_7
Xbit_r41_c31 bl[31] br[31] wl[41] gnd reram_bitcell_7
Xbit_r42_c31 bl[31] br[31] wl[42] gnd reram_bitcell_7
Xbit_r43_c31 bl[31] br[31] wl[43] gnd reram_bitcell_7
Xbit_r44_c31 bl[31] br[31] wl[44] gnd reram_bitcell_7
Xbit_r45_c31 bl[31] br[31] wl[45] gnd reram_bitcell_7
Xbit_r46_c31 bl[31] br[31] wl[46] gnd reram_bitcell_7
Xbit_r47_c31 bl[31] br[31] wl[47] gnd reram_bitcell_7
Xbit_r48_c31 bl[31] br[31] wl[48] gnd reram_bitcell_7
Xbit_r49_c31 bl[31] br[31] wl[49] gnd reram_bitcell_7
Xbit_r50_c31 bl[31] br[31] wl[50] gnd reram_bitcell_7
Xbit_r51_c31 bl[31] br[31] wl[51] gnd reram_bitcell_7
Xbit_r52_c31 bl[31] br[31] wl[52] gnd reram_bitcell_7
Xbit_r53_c31 bl[31] br[31] wl[53] gnd reram_bitcell_7
Xbit_r54_c31 bl[31] br[31] wl[54] gnd reram_bitcell_7
Xbit_r55_c31 bl[31] br[31] wl[55] gnd reram_bitcell_7
Xbit_r56_c31 bl[31] br[31] wl[56] gnd reram_bitcell_7
Xbit_r57_c31 bl[31] br[31] wl[57] gnd reram_bitcell_7
Xbit_r58_c31 bl[31] br[31] wl[58] gnd reram_bitcell_7
Xbit_r59_c31 bl[31] br[31] wl[59] gnd reram_bitcell_7
Xbit_r60_c31 bl[31] br[31] wl[60] gnd reram_bitcell_7
Xbit_r61_c31 bl[31] br[31] wl[61] gnd reram_bitcell_7
Xbit_r62_c31 bl[31] br[31] wl[62] gnd reram_bitcell_7
Xbit_r63_c31 bl[31] br[31] wl[63] gnd reram_bitcell_7
Xbit_r0_c32 bl[32] br[32] wl[0] gnd reram_bitcell_7
Xbit_r1_c32 bl[32] br[32] wl[1] gnd reram_bitcell_7
Xbit_r2_c32 bl[32] br[32] wl[2] gnd reram_bitcell_7
Xbit_r3_c32 bl[32] br[32] wl[3] gnd reram_bitcell_7
Xbit_r4_c32 bl[32] br[32] wl[4] gnd reram_bitcell_7
Xbit_r5_c32 bl[32] br[32] wl[5] gnd reram_bitcell_7
Xbit_r6_c32 bl[32] br[32] wl[6] gnd reram_bitcell_7
Xbit_r7_c32 bl[32] br[32] wl[7] gnd reram_bitcell_7
Xbit_r8_c32 bl[32] br[32] wl[8] gnd reram_bitcell_7
Xbit_r9_c32 bl[32] br[32] wl[9] gnd reram_bitcell_7
Xbit_r10_c32 bl[32] br[32] wl[10] gnd reram_bitcell_7
Xbit_r11_c32 bl[32] br[32] wl[11] gnd reram_bitcell_7
Xbit_r12_c32 bl[32] br[32] wl[12] gnd reram_bitcell_7
Xbit_r13_c32 bl[32] br[32] wl[13] gnd reram_bitcell_7
Xbit_r14_c32 bl[32] br[32] wl[14] gnd reram_bitcell_7
Xbit_r15_c32 bl[32] br[32] wl[15] gnd reram_bitcell_7
Xbit_r16_c32 bl[32] br[32] wl[16] gnd reram_bitcell_7
Xbit_r17_c32 bl[32] br[32] wl[17] gnd reram_bitcell_7
Xbit_r18_c32 bl[32] br[32] wl[18] gnd reram_bitcell_7
Xbit_r19_c32 bl[32] br[32] wl[19] gnd reram_bitcell_7
Xbit_r20_c32 bl[32] br[32] wl[20] gnd reram_bitcell_7
Xbit_r21_c32 bl[32] br[32] wl[21] gnd reram_bitcell_7
Xbit_r22_c32 bl[32] br[32] wl[22] gnd reram_bitcell_7
Xbit_r23_c32 bl[32] br[32] wl[23] gnd reram_bitcell_7
Xbit_r24_c32 bl[32] br[32] wl[24] gnd reram_bitcell_7
Xbit_r25_c32 bl[32] br[32] wl[25] gnd reram_bitcell_7
Xbit_r26_c32 bl[32] br[32] wl[26] gnd reram_bitcell_7
Xbit_r27_c32 bl[32] br[32] wl[27] gnd reram_bitcell_7
Xbit_r28_c32 bl[32] br[32] wl[28] gnd reram_bitcell_7
Xbit_r29_c32 bl[32] br[32] wl[29] gnd reram_bitcell_7
Xbit_r30_c32 bl[32] br[32] wl[30] gnd reram_bitcell_7
Xbit_r31_c32 bl[32] br[32] wl[31] gnd reram_bitcell_7
Xbit_r32_c32 bl[32] br[32] wl[32] gnd reram_bitcell_7
Xbit_r33_c32 bl[32] br[32] wl[33] gnd reram_bitcell_7
Xbit_r34_c32 bl[32] br[32] wl[34] gnd reram_bitcell_7
Xbit_r35_c32 bl[32] br[32] wl[35] gnd reram_bitcell_7
Xbit_r36_c32 bl[32] br[32] wl[36] gnd reram_bitcell_7
Xbit_r37_c32 bl[32] br[32] wl[37] gnd reram_bitcell_7
Xbit_r38_c32 bl[32] br[32] wl[38] gnd reram_bitcell_7
Xbit_r39_c32 bl[32] br[32] wl[39] gnd reram_bitcell_7
Xbit_r40_c32 bl[32] br[32] wl[40] gnd reram_bitcell_7
Xbit_r41_c32 bl[32] br[32] wl[41] gnd reram_bitcell_7
Xbit_r42_c32 bl[32] br[32] wl[42] gnd reram_bitcell_7
Xbit_r43_c32 bl[32] br[32] wl[43] gnd reram_bitcell_7
Xbit_r44_c32 bl[32] br[32] wl[44] gnd reram_bitcell_7
Xbit_r45_c32 bl[32] br[32] wl[45] gnd reram_bitcell_7
Xbit_r46_c32 bl[32] br[32] wl[46] gnd reram_bitcell_7
Xbit_r47_c32 bl[32] br[32] wl[47] gnd reram_bitcell_7
Xbit_r48_c32 bl[32] br[32] wl[48] gnd reram_bitcell_7
Xbit_r49_c32 bl[32] br[32] wl[49] gnd reram_bitcell_7
Xbit_r50_c32 bl[32] br[32] wl[50] gnd reram_bitcell_7
Xbit_r51_c32 bl[32] br[32] wl[51] gnd reram_bitcell_7
Xbit_r52_c32 bl[32] br[32] wl[52] gnd reram_bitcell_7
Xbit_r53_c32 bl[32] br[32] wl[53] gnd reram_bitcell_7
Xbit_r54_c32 bl[32] br[32] wl[54] gnd reram_bitcell_7
Xbit_r55_c32 bl[32] br[32] wl[55] gnd reram_bitcell_7
Xbit_r56_c32 bl[32] br[32] wl[56] gnd reram_bitcell_7
Xbit_r57_c32 bl[32] br[32] wl[57] gnd reram_bitcell_7
Xbit_r58_c32 bl[32] br[32] wl[58] gnd reram_bitcell_7
Xbit_r59_c32 bl[32] br[32] wl[59] gnd reram_bitcell_7
Xbit_r60_c32 bl[32] br[32] wl[60] gnd reram_bitcell_7
Xbit_r61_c32 bl[32] br[32] wl[61] gnd reram_bitcell_7
Xbit_r62_c32 bl[32] br[32] wl[62] gnd reram_bitcell_7
Xbit_r63_c32 bl[32] br[32] wl[63] gnd reram_bitcell_7
Xbit_r0_c33 bl[33] br[33] wl[0] gnd reram_bitcell_7
Xbit_r1_c33 bl[33] br[33] wl[1] gnd reram_bitcell_7
Xbit_r2_c33 bl[33] br[33] wl[2] gnd reram_bitcell_7
Xbit_r3_c33 bl[33] br[33] wl[3] gnd reram_bitcell_7
Xbit_r4_c33 bl[33] br[33] wl[4] gnd reram_bitcell_7
Xbit_r5_c33 bl[33] br[33] wl[5] gnd reram_bitcell_7
Xbit_r6_c33 bl[33] br[33] wl[6] gnd reram_bitcell_7
Xbit_r7_c33 bl[33] br[33] wl[7] gnd reram_bitcell_7
Xbit_r8_c33 bl[33] br[33] wl[8] gnd reram_bitcell_7
Xbit_r9_c33 bl[33] br[33] wl[9] gnd reram_bitcell_7
Xbit_r10_c33 bl[33] br[33] wl[10] gnd reram_bitcell_7
Xbit_r11_c33 bl[33] br[33] wl[11] gnd reram_bitcell_7
Xbit_r12_c33 bl[33] br[33] wl[12] gnd reram_bitcell_7
Xbit_r13_c33 bl[33] br[33] wl[13] gnd reram_bitcell_7
Xbit_r14_c33 bl[33] br[33] wl[14] gnd reram_bitcell_7
Xbit_r15_c33 bl[33] br[33] wl[15] gnd reram_bitcell_7
Xbit_r16_c33 bl[33] br[33] wl[16] gnd reram_bitcell_7
Xbit_r17_c33 bl[33] br[33] wl[17] gnd reram_bitcell_7
Xbit_r18_c33 bl[33] br[33] wl[18] gnd reram_bitcell_7
Xbit_r19_c33 bl[33] br[33] wl[19] gnd reram_bitcell_7
Xbit_r20_c33 bl[33] br[33] wl[20] gnd reram_bitcell_7
Xbit_r21_c33 bl[33] br[33] wl[21] gnd reram_bitcell_7
Xbit_r22_c33 bl[33] br[33] wl[22] gnd reram_bitcell_7
Xbit_r23_c33 bl[33] br[33] wl[23] gnd reram_bitcell_7
Xbit_r24_c33 bl[33] br[33] wl[24] gnd reram_bitcell_7
Xbit_r25_c33 bl[33] br[33] wl[25] gnd reram_bitcell_7
Xbit_r26_c33 bl[33] br[33] wl[26] gnd reram_bitcell_7
Xbit_r27_c33 bl[33] br[33] wl[27] gnd reram_bitcell_7
Xbit_r28_c33 bl[33] br[33] wl[28] gnd reram_bitcell_7
Xbit_r29_c33 bl[33] br[33] wl[29] gnd reram_bitcell_7
Xbit_r30_c33 bl[33] br[33] wl[30] gnd reram_bitcell_7
Xbit_r31_c33 bl[33] br[33] wl[31] gnd reram_bitcell_7
Xbit_r32_c33 bl[33] br[33] wl[32] gnd reram_bitcell_7
Xbit_r33_c33 bl[33] br[33] wl[33] gnd reram_bitcell_7
Xbit_r34_c33 bl[33] br[33] wl[34] gnd reram_bitcell_7
Xbit_r35_c33 bl[33] br[33] wl[35] gnd reram_bitcell_7
Xbit_r36_c33 bl[33] br[33] wl[36] gnd reram_bitcell_7
Xbit_r37_c33 bl[33] br[33] wl[37] gnd reram_bitcell_7
Xbit_r38_c33 bl[33] br[33] wl[38] gnd reram_bitcell_7
Xbit_r39_c33 bl[33] br[33] wl[39] gnd reram_bitcell_7
Xbit_r40_c33 bl[33] br[33] wl[40] gnd reram_bitcell_7
Xbit_r41_c33 bl[33] br[33] wl[41] gnd reram_bitcell_7
Xbit_r42_c33 bl[33] br[33] wl[42] gnd reram_bitcell_7
Xbit_r43_c33 bl[33] br[33] wl[43] gnd reram_bitcell_7
Xbit_r44_c33 bl[33] br[33] wl[44] gnd reram_bitcell_7
Xbit_r45_c33 bl[33] br[33] wl[45] gnd reram_bitcell_7
Xbit_r46_c33 bl[33] br[33] wl[46] gnd reram_bitcell_7
Xbit_r47_c33 bl[33] br[33] wl[47] gnd reram_bitcell_7
Xbit_r48_c33 bl[33] br[33] wl[48] gnd reram_bitcell_7
Xbit_r49_c33 bl[33] br[33] wl[49] gnd reram_bitcell_7
Xbit_r50_c33 bl[33] br[33] wl[50] gnd reram_bitcell_7
Xbit_r51_c33 bl[33] br[33] wl[51] gnd reram_bitcell_7
Xbit_r52_c33 bl[33] br[33] wl[52] gnd reram_bitcell_7
Xbit_r53_c33 bl[33] br[33] wl[53] gnd reram_bitcell_7
Xbit_r54_c33 bl[33] br[33] wl[54] gnd reram_bitcell_7
Xbit_r55_c33 bl[33] br[33] wl[55] gnd reram_bitcell_7
Xbit_r56_c33 bl[33] br[33] wl[56] gnd reram_bitcell_7
Xbit_r57_c33 bl[33] br[33] wl[57] gnd reram_bitcell_7
Xbit_r58_c33 bl[33] br[33] wl[58] gnd reram_bitcell_7
Xbit_r59_c33 bl[33] br[33] wl[59] gnd reram_bitcell_7
Xbit_r60_c33 bl[33] br[33] wl[60] gnd reram_bitcell_7
Xbit_r61_c33 bl[33] br[33] wl[61] gnd reram_bitcell_7
Xbit_r62_c33 bl[33] br[33] wl[62] gnd reram_bitcell_7
Xbit_r63_c33 bl[33] br[33] wl[63] gnd reram_bitcell_7
Xbit_r0_c34 bl[34] br[34] wl[0] gnd reram_bitcell_7
Xbit_r1_c34 bl[34] br[34] wl[1] gnd reram_bitcell_7
Xbit_r2_c34 bl[34] br[34] wl[2] gnd reram_bitcell_7
Xbit_r3_c34 bl[34] br[34] wl[3] gnd reram_bitcell_7
Xbit_r4_c34 bl[34] br[34] wl[4] gnd reram_bitcell_7
Xbit_r5_c34 bl[34] br[34] wl[5] gnd reram_bitcell_7
Xbit_r6_c34 bl[34] br[34] wl[6] gnd reram_bitcell_7
Xbit_r7_c34 bl[34] br[34] wl[7] gnd reram_bitcell_7
Xbit_r8_c34 bl[34] br[34] wl[8] gnd reram_bitcell_7
Xbit_r9_c34 bl[34] br[34] wl[9] gnd reram_bitcell_7
Xbit_r10_c34 bl[34] br[34] wl[10] gnd reram_bitcell_7
Xbit_r11_c34 bl[34] br[34] wl[11] gnd reram_bitcell_7
Xbit_r12_c34 bl[34] br[34] wl[12] gnd reram_bitcell_7
Xbit_r13_c34 bl[34] br[34] wl[13] gnd reram_bitcell_7
Xbit_r14_c34 bl[34] br[34] wl[14] gnd reram_bitcell_7
Xbit_r15_c34 bl[34] br[34] wl[15] gnd reram_bitcell_7
Xbit_r16_c34 bl[34] br[34] wl[16] gnd reram_bitcell_7
Xbit_r17_c34 bl[34] br[34] wl[17] gnd reram_bitcell_7
Xbit_r18_c34 bl[34] br[34] wl[18] gnd reram_bitcell_7
Xbit_r19_c34 bl[34] br[34] wl[19] gnd reram_bitcell_7
Xbit_r20_c34 bl[34] br[34] wl[20] gnd reram_bitcell_7
Xbit_r21_c34 bl[34] br[34] wl[21] gnd reram_bitcell_7
Xbit_r22_c34 bl[34] br[34] wl[22] gnd reram_bitcell_7
Xbit_r23_c34 bl[34] br[34] wl[23] gnd reram_bitcell_7
Xbit_r24_c34 bl[34] br[34] wl[24] gnd reram_bitcell_7
Xbit_r25_c34 bl[34] br[34] wl[25] gnd reram_bitcell_7
Xbit_r26_c34 bl[34] br[34] wl[26] gnd reram_bitcell_7
Xbit_r27_c34 bl[34] br[34] wl[27] gnd reram_bitcell_7
Xbit_r28_c34 bl[34] br[34] wl[28] gnd reram_bitcell_7
Xbit_r29_c34 bl[34] br[34] wl[29] gnd reram_bitcell_7
Xbit_r30_c34 bl[34] br[34] wl[30] gnd reram_bitcell_7
Xbit_r31_c34 bl[34] br[34] wl[31] gnd reram_bitcell_7
Xbit_r32_c34 bl[34] br[34] wl[32] gnd reram_bitcell_7
Xbit_r33_c34 bl[34] br[34] wl[33] gnd reram_bitcell_7
Xbit_r34_c34 bl[34] br[34] wl[34] gnd reram_bitcell_7
Xbit_r35_c34 bl[34] br[34] wl[35] gnd reram_bitcell_7
Xbit_r36_c34 bl[34] br[34] wl[36] gnd reram_bitcell_7
Xbit_r37_c34 bl[34] br[34] wl[37] gnd reram_bitcell_7
Xbit_r38_c34 bl[34] br[34] wl[38] gnd reram_bitcell_7
Xbit_r39_c34 bl[34] br[34] wl[39] gnd reram_bitcell_7
Xbit_r40_c34 bl[34] br[34] wl[40] gnd reram_bitcell_7
Xbit_r41_c34 bl[34] br[34] wl[41] gnd reram_bitcell_7
Xbit_r42_c34 bl[34] br[34] wl[42] gnd reram_bitcell_7
Xbit_r43_c34 bl[34] br[34] wl[43] gnd reram_bitcell_7
Xbit_r44_c34 bl[34] br[34] wl[44] gnd reram_bitcell_7
Xbit_r45_c34 bl[34] br[34] wl[45] gnd reram_bitcell_7
Xbit_r46_c34 bl[34] br[34] wl[46] gnd reram_bitcell_7
Xbit_r47_c34 bl[34] br[34] wl[47] gnd reram_bitcell_7
Xbit_r48_c34 bl[34] br[34] wl[48] gnd reram_bitcell_7
Xbit_r49_c34 bl[34] br[34] wl[49] gnd reram_bitcell_7
Xbit_r50_c34 bl[34] br[34] wl[50] gnd reram_bitcell_7
Xbit_r51_c34 bl[34] br[34] wl[51] gnd reram_bitcell_7
Xbit_r52_c34 bl[34] br[34] wl[52] gnd reram_bitcell_7
Xbit_r53_c34 bl[34] br[34] wl[53] gnd reram_bitcell_7
Xbit_r54_c34 bl[34] br[34] wl[54] gnd reram_bitcell_7
Xbit_r55_c34 bl[34] br[34] wl[55] gnd reram_bitcell_7
Xbit_r56_c34 bl[34] br[34] wl[56] gnd reram_bitcell_7
Xbit_r57_c34 bl[34] br[34] wl[57] gnd reram_bitcell_7
Xbit_r58_c34 bl[34] br[34] wl[58] gnd reram_bitcell_7
Xbit_r59_c34 bl[34] br[34] wl[59] gnd reram_bitcell_7
Xbit_r60_c34 bl[34] br[34] wl[60] gnd reram_bitcell_7
Xbit_r61_c34 bl[34] br[34] wl[61] gnd reram_bitcell_7
Xbit_r62_c34 bl[34] br[34] wl[62] gnd reram_bitcell_7
Xbit_r63_c34 bl[34] br[34] wl[63] gnd reram_bitcell_7
Xbit_r0_c35 bl[35] br[35] wl[0] gnd reram_bitcell_7
Xbit_r1_c35 bl[35] br[35] wl[1] gnd reram_bitcell_7
Xbit_r2_c35 bl[35] br[35] wl[2] gnd reram_bitcell_7
Xbit_r3_c35 bl[35] br[35] wl[3] gnd reram_bitcell_7
Xbit_r4_c35 bl[35] br[35] wl[4] gnd reram_bitcell_7
Xbit_r5_c35 bl[35] br[35] wl[5] gnd reram_bitcell_7
Xbit_r6_c35 bl[35] br[35] wl[6] gnd reram_bitcell_7
Xbit_r7_c35 bl[35] br[35] wl[7] gnd reram_bitcell_7
Xbit_r8_c35 bl[35] br[35] wl[8] gnd reram_bitcell_7
Xbit_r9_c35 bl[35] br[35] wl[9] gnd reram_bitcell_7
Xbit_r10_c35 bl[35] br[35] wl[10] gnd reram_bitcell_7
Xbit_r11_c35 bl[35] br[35] wl[11] gnd reram_bitcell_7
Xbit_r12_c35 bl[35] br[35] wl[12] gnd reram_bitcell_7
Xbit_r13_c35 bl[35] br[35] wl[13] gnd reram_bitcell_7
Xbit_r14_c35 bl[35] br[35] wl[14] gnd reram_bitcell_7
Xbit_r15_c35 bl[35] br[35] wl[15] gnd reram_bitcell_7
Xbit_r16_c35 bl[35] br[35] wl[16] gnd reram_bitcell_7
Xbit_r17_c35 bl[35] br[35] wl[17] gnd reram_bitcell_7
Xbit_r18_c35 bl[35] br[35] wl[18] gnd reram_bitcell_7
Xbit_r19_c35 bl[35] br[35] wl[19] gnd reram_bitcell_7
Xbit_r20_c35 bl[35] br[35] wl[20] gnd reram_bitcell_7
Xbit_r21_c35 bl[35] br[35] wl[21] gnd reram_bitcell_7
Xbit_r22_c35 bl[35] br[35] wl[22] gnd reram_bitcell_7
Xbit_r23_c35 bl[35] br[35] wl[23] gnd reram_bitcell_7
Xbit_r24_c35 bl[35] br[35] wl[24] gnd reram_bitcell_7
Xbit_r25_c35 bl[35] br[35] wl[25] gnd reram_bitcell_7
Xbit_r26_c35 bl[35] br[35] wl[26] gnd reram_bitcell_7
Xbit_r27_c35 bl[35] br[35] wl[27] gnd reram_bitcell_7
Xbit_r28_c35 bl[35] br[35] wl[28] gnd reram_bitcell_7
Xbit_r29_c35 bl[35] br[35] wl[29] gnd reram_bitcell_7
Xbit_r30_c35 bl[35] br[35] wl[30] gnd reram_bitcell_7
Xbit_r31_c35 bl[35] br[35] wl[31] gnd reram_bitcell_7
Xbit_r32_c35 bl[35] br[35] wl[32] gnd reram_bitcell_7
Xbit_r33_c35 bl[35] br[35] wl[33] gnd reram_bitcell_7
Xbit_r34_c35 bl[35] br[35] wl[34] gnd reram_bitcell_7
Xbit_r35_c35 bl[35] br[35] wl[35] gnd reram_bitcell_7
Xbit_r36_c35 bl[35] br[35] wl[36] gnd reram_bitcell_7
Xbit_r37_c35 bl[35] br[35] wl[37] gnd reram_bitcell_7
Xbit_r38_c35 bl[35] br[35] wl[38] gnd reram_bitcell_7
Xbit_r39_c35 bl[35] br[35] wl[39] gnd reram_bitcell_7
Xbit_r40_c35 bl[35] br[35] wl[40] gnd reram_bitcell_7
Xbit_r41_c35 bl[35] br[35] wl[41] gnd reram_bitcell_7
Xbit_r42_c35 bl[35] br[35] wl[42] gnd reram_bitcell_7
Xbit_r43_c35 bl[35] br[35] wl[43] gnd reram_bitcell_7
Xbit_r44_c35 bl[35] br[35] wl[44] gnd reram_bitcell_7
Xbit_r45_c35 bl[35] br[35] wl[45] gnd reram_bitcell_7
Xbit_r46_c35 bl[35] br[35] wl[46] gnd reram_bitcell_7
Xbit_r47_c35 bl[35] br[35] wl[47] gnd reram_bitcell_7
Xbit_r48_c35 bl[35] br[35] wl[48] gnd reram_bitcell_7
Xbit_r49_c35 bl[35] br[35] wl[49] gnd reram_bitcell_7
Xbit_r50_c35 bl[35] br[35] wl[50] gnd reram_bitcell_7
Xbit_r51_c35 bl[35] br[35] wl[51] gnd reram_bitcell_7
Xbit_r52_c35 bl[35] br[35] wl[52] gnd reram_bitcell_7
Xbit_r53_c35 bl[35] br[35] wl[53] gnd reram_bitcell_7
Xbit_r54_c35 bl[35] br[35] wl[54] gnd reram_bitcell_7
Xbit_r55_c35 bl[35] br[35] wl[55] gnd reram_bitcell_7
Xbit_r56_c35 bl[35] br[35] wl[56] gnd reram_bitcell_7
Xbit_r57_c35 bl[35] br[35] wl[57] gnd reram_bitcell_7
Xbit_r58_c35 bl[35] br[35] wl[58] gnd reram_bitcell_7
Xbit_r59_c35 bl[35] br[35] wl[59] gnd reram_bitcell_7
Xbit_r60_c35 bl[35] br[35] wl[60] gnd reram_bitcell_7
Xbit_r61_c35 bl[35] br[35] wl[61] gnd reram_bitcell_7
Xbit_r62_c35 bl[35] br[35] wl[62] gnd reram_bitcell_7
Xbit_r63_c35 bl[35] br[35] wl[63] gnd reram_bitcell_7
Xbit_r0_c36 bl[36] br[36] wl[0] gnd reram_bitcell_7
Xbit_r1_c36 bl[36] br[36] wl[1] gnd reram_bitcell_7
Xbit_r2_c36 bl[36] br[36] wl[2] gnd reram_bitcell_7
Xbit_r3_c36 bl[36] br[36] wl[3] gnd reram_bitcell_7
Xbit_r4_c36 bl[36] br[36] wl[4] gnd reram_bitcell_7
Xbit_r5_c36 bl[36] br[36] wl[5] gnd reram_bitcell_7
Xbit_r6_c36 bl[36] br[36] wl[6] gnd reram_bitcell_7
Xbit_r7_c36 bl[36] br[36] wl[7] gnd reram_bitcell_7
Xbit_r8_c36 bl[36] br[36] wl[8] gnd reram_bitcell_7
Xbit_r9_c36 bl[36] br[36] wl[9] gnd reram_bitcell_7
Xbit_r10_c36 bl[36] br[36] wl[10] gnd reram_bitcell_7
Xbit_r11_c36 bl[36] br[36] wl[11] gnd reram_bitcell_7
Xbit_r12_c36 bl[36] br[36] wl[12] gnd reram_bitcell_7
Xbit_r13_c36 bl[36] br[36] wl[13] gnd reram_bitcell_7
Xbit_r14_c36 bl[36] br[36] wl[14] gnd reram_bitcell_7
Xbit_r15_c36 bl[36] br[36] wl[15] gnd reram_bitcell_7
Xbit_r16_c36 bl[36] br[36] wl[16] gnd reram_bitcell_7
Xbit_r17_c36 bl[36] br[36] wl[17] gnd reram_bitcell_7
Xbit_r18_c36 bl[36] br[36] wl[18] gnd reram_bitcell_7
Xbit_r19_c36 bl[36] br[36] wl[19] gnd reram_bitcell_7
Xbit_r20_c36 bl[36] br[36] wl[20] gnd reram_bitcell_7
Xbit_r21_c36 bl[36] br[36] wl[21] gnd reram_bitcell_7
Xbit_r22_c36 bl[36] br[36] wl[22] gnd reram_bitcell_7
Xbit_r23_c36 bl[36] br[36] wl[23] gnd reram_bitcell_7
Xbit_r24_c36 bl[36] br[36] wl[24] gnd reram_bitcell_7
Xbit_r25_c36 bl[36] br[36] wl[25] gnd reram_bitcell_7
Xbit_r26_c36 bl[36] br[36] wl[26] gnd reram_bitcell_7
Xbit_r27_c36 bl[36] br[36] wl[27] gnd reram_bitcell_7
Xbit_r28_c36 bl[36] br[36] wl[28] gnd reram_bitcell_7
Xbit_r29_c36 bl[36] br[36] wl[29] gnd reram_bitcell_7
Xbit_r30_c36 bl[36] br[36] wl[30] gnd reram_bitcell_7
Xbit_r31_c36 bl[36] br[36] wl[31] gnd reram_bitcell_7
Xbit_r32_c36 bl[36] br[36] wl[32] gnd reram_bitcell_7
Xbit_r33_c36 bl[36] br[36] wl[33] gnd reram_bitcell_7
Xbit_r34_c36 bl[36] br[36] wl[34] gnd reram_bitcell_7
Xbit_r35_c36 bl[36] br[36] wl[35] gnd reram_bitcell_7
Xbit_r36_c36 bl[36] br[36] wl[36] gnd reram_bitcell_7
Xbit_r37_c36 bl[36] br[36] wl[37] gnd reram_bitcell_7
Xbit_r38_c36 bl[36] br[36] wl[38] gnd reram_bitcell_7
Xbit_r39_c36 bl[36] br[36] wl[39] gnd reram_bitcell_7
Xbit_r40_c36 bl[36] br[36] wl[40] gnd reram_bitcell_7
Xbit_r41_c36 bl[36] br[36] wl[41] gnd reram_bitcell_7
Xbit_r42_c36 bl[36] br[36] wl[42] gnd reram_bitcell_7
Xbit_r43_c36 bl[36] br[36] wl[43] gnd reram_bitcell_7
Xbit_r44_c36 bl[36] br[36] wl[44] gnd reram_bitcell_7
Xbit_r45_c36 bl[36] br[36] wl[45] gnd reram_bitcell_7
Xbit_r46_c36 bl[36] br[36] wl[46] gnd reram_bitcell_7
Xbit_r47_c36 bl[36] br[36] wl[47] gnd reram_bitcell_7
Xbit_r48_c36 bl[36] br[36] wl[48] gnd reram_bitcell_7
Xbit_r49_c36 bl[36] br[36] wl[49] gnd reram_bitcell_7
Xbit_r50_c36 bl[36] br[36] wl[50] gnd reram_bitcell_7
Xbit_r51_c36 bl[36] br[36] wl[51] gnd reram_bitcell_7
Xbit_r52_c36 bl[36] br[36] wl[52] gnd reram_bitcell_7
Xbit_r53_c36 bl[36] br[36] wl[53] gnd reram_bitcell_7
Xbit_r54_c36 bl[36] br[36] wl[54] gnd reram_bitcell_7
Xbit_r55_c36 bl[36] br[36] wl[55] gnd reram_bitcell_7
Xbit_r56_c36 bl[36] br[36] wl[56] gnd reram_bitcell_7
Xbit_r57_c36 bl[36] br[36] wl[57] gnd reram_bitcell_7
Xbit_r58_c36 bl[36] br[36] wl[58] gnd reram_bitcell_7
Xbit_r59_c36 bl[36] br[36] wl[59] gnd reram_bitcell_7
Xbit_r60_c36 bl[36] br[36] wl[60] gnd reram_bitcell_7
Xbit_r61_c36 bl[36] br[36] wl[61] gnd reram_bitcell_7
Xbit_r62_c36 bl[36] br[36] wl[62] gnd reram_bitcell_7
Xbit_r63_c36 bl[36] br[36] wl[63] gnd reram_bitcell_7
Xbit_r0_c37 bl[37] br[37] wl[0] gnd reram_bitcell_7
Xbit_r1_c37 bl[37] br[37] wl[1] gnd reram_bitcell_7
Xbit_r2_c37 bl[37] br[37] wl[2] gnd reram_bitcell_7
Xbit_r3_c37 bl[37] br[37] wl[3] gnd reram_bitcell_7
Xbit_r4_c37 bl[37] br[37] wl[4] gnd reram_bitcell_7
Xbit_r5_c37 bl[37] br[37] wl[5] gnd reram_bitcell_7
Xbit_r6_c37 bl[37] br[37] wl[6] gnd reram_bitcell_7
Xbit_r7_c37 bl[37] br[37] wl[7] gnd reram_bitcell_7
Xbit_r8_c37 bl[37] br[37] wl[8] gnd reram_bitcell_7
Xbit_r9_c37 bl[37] br[37] wl[9] gnd reram_bitcell_7
Xbit_r10_c37 bl[37] br[37] wl[10] gnd reram_bitcell_7
Xbit_r11_c37 bl[37] br[37] wl[11] gnd reram_bitcell_7
Xbit_r12_c37 bl[37] br[37] wl[12] gnd reram_bitcell_7
Xbit_r13_c37 bl[37] br[37] wl[13] gnd reram_bitcell_7
Xbit_r14_c37 bl[37] br[37] wl[14] gnd reram_bitcell_7
Xbit_r15_c37 bl[37] br[37] wl[15] gnd reram_bitcell_7
Xbit_r16_c37 bl[37] br[37] wl[16] gnd reram_bitcell_7
Xbit_r17_c37 bl[37] br[37] wl[17] gnd reram_bitcell_7
Xbit_r18_c37 bl[37] br[37] wl[18] gnd reram_bitcell_7
Xbit_r19_c37 bl[37] br[37] wl[19] gnd reram_bitcell_7
Xbit_r20_c37 bl[37] br[37] wl[20] gnd reram_bitcell_7
Xbit_r21_c37 bl[37] br[37] wl[21] gnd reram_bitcell_7
Xbit_r22_c37 bl[37] br[37] wl[22] gnd reram_bitcell_7
Xbit_r23_c37 bl[37] br[37] wl[23] gnd reram_bitcell_7
Xbit_r24_c37 bl[37] br[37] wl[24] gnd reram_bitcell_7
Xbit_r25_c37 bl[37] br[37] wl[25] gnd reram_bitcell_7
Xbit_r26_c37 bl[37] br[37] wl[26] gnd reram_bitcell_7
Xbit_r27_c37 bl[37] br[37] wl[27] gnd reram_bitcell_7
Xbit_r28_c37 bl[37] br[37] wl[28] gnd reram_bitcell_7
Xbit_r29_c37 bl[37] br[37] wl[29] gnd reram_bitcell_7
Xbit_r30_c37 bl[37] br[37] wl[30] gnd reram_bitcell_7
Xbit_r31_c37 bl[37] br[37] wl[31] gnd reram_bitcell_7
Xbit_r32_c37 bl[37] br[37] wl[32] gnd reram_bitcell_7
Xbit_r33_c37 bl[37] br[37] wl[33] gnd reram_bitcell_7
Xbit_r34_c37 bl[37] br[37] wl[34] gnd reram_bitcell_7
Xbit_r35_c37 bl[37] br[37] wl[35] gnd reram_bitcell_7
Xbit_r36_c37 bl[37] br[37] wl[36] gnd reram_bitcell_7
Xbit_r37_c37 bl[37] br[37] wl[37] gnd reram_bitcell_7
Xbit_r38_c37 bl[37] br[37] wl[38] gnd reram_bitcell_7
Xbit_r39_c37 bl[37] br[37] wl[39] gnd reram_bitcell_7
Xbit_r40_c37 bl[37] br[37] wl[40] gnd reram_bitcell_7
Xbit_r41_c37 bl[37] br[37] wl[41] gnd reram_bitcell_7
Xbit_r42_c37 bl[37] br[37] wl[42] gnd reram_bitcell_7
Xbit_r43_c37 bl[37] br[37] wl[43] gnd reram_bitcell_7
Xbit_r44_c37 bl[37] br[37] wl[44] gnd reram_bitcell_7
Xbit_r45_c37 bl[37] br[37] wl[45] gnd reram_bitcell_7
Xbit_r46_c37 bl[37] br[37] wl[46] gnd reram_bitcell_7
Xbit_r47_c37 bl[37] br[37] wl[47] gnd reram_bitcell_7
Xbit_r48_c37 bl[37] br[37] wl[48] gnd reram_bitcell_7
Xbit_r49_c37 bl[37] br[37] wl[49] gnd reram_bitcell_7
Xbit_r50_c37 bl[37] br[37] wl[50] gnd reram_bitcell_7
Xbit_r51_c37 bl[37] br[37] wl[51] gnd reram_bitcell_7
Xbit_r52_c37 bl[37] br[37] wl[52] gnd reram_bitcell_7
Xbit_r53_c37 bl[37] br[37] wl[53] gnd reram_bitcell_7
Xbit_r54_c37 bl[37] br[37] wl[54] gnd reram_bitcell_7
Xbit_r55_c37 bl[37] br[37] wl[55] gnd reram_bitcell_7
Xbit_r56_c37 bl[37] br[37] wl[56] gnd reram_bitcell_7
Xbit_r57_c37 bl[37] br[37] wl[57] gnd reram_bitcell_7
Xbit_r58_c37 bl[37] br[37] wl[58] gnd reram_bitcell_7
Xbit_r59_c37 bl[37] br[37] wl[59] gnd reram_bitcell_7
Xbit_r60_c37 bl[37] br[37] wl[60] gnd reram_bitcell_7
Xbit_r61_c37 bl[37] br[37] wl[61] gnd reram_bitcell_7
Xbit_r62_c37 bl[37] br[37] wl[62] gnd reram_bitcell_7
Xbit_r63_c37 bl[37] br[37] wl[63] gnd reram_bitcell_7
Xbit_r0_c38 bl[38] br[38] wl[0] gnd reram_bitcell_7
Xbit_r1_c38 bl[38] br[38] wl[1] gnd reram_bitcell_7
Xbit_r2_c38 bl[38] br[38] wl[2] gnd reram_bitcell_7
Xbit_r3_c38 bl[38] br[38] wl[3] gnd reram_bitcell_7
Xbit_r4_c38 bl[38] br[38] wl[4] gnd reram_bitcell_7
Xbit_r5_c38 bl[38] br[38] wl[5] gnd reram_bitcell_7
Xbit_r6_c38 bl[38] br[38] wl[6] gnd reram_bitcell_7
Xbit_r7_c38 bl[38] br[38] wl[7] gnd reram_bitcell_7
Xbit_r8_c38 bl[38] br[38] wl[8] gnd reram_bitcell_7
Xbit_r9_c38 bl[38] br[38] wl[9] gnd reram_bitcell_7
Xbit_r10_c38 bl[38] br[38] wl[10] gnd reram_bitcell_7
Xbit_r11_c38 bl[38] br[38] wl[11] gnd reram_bitcell_7
Xbit_r12_c38 bl[38] br[38] wl[12] gnd reram_bitcell_7
Xbit_r13_c38 bl[38] br[38] wl[13] gnd reram_bitcell_7
Xbit_r14_c38 bl[38] br[38] wl[14] gnd reram_bitcell_7
Xbit_r15_c38 bl[38] br[38] wl[15] gnd reram_bitcell_7
Xbit_r16_c38 bl[38] br[38] wl[16] gnd reram_bitcell_7
Xbit_r17_c38 bl[38] br[38] wl[17] gnd reram_bitcell_7
Xbit_r18_c38 bl[38] br[38] wl[18] gnd reram_bitcell_7
Xbit_r19_c38 bl[38] br[38] wl[19] gnd reram_bitcell_7
Xbit_r20_c38 bl[38] br[38] wl[20] gnd reram_bitcell_7
Xbit_r21_c38 bl[38] br[38] wl[21] gnd reram_bitcell_7
Xbit_r22_c38 bl[38] br[38] wl[22] gnd reram_bitcell_7
Xbit_r23_c38 bl[38] br[38] wl[23] gnd reram_bitcell_7
Xbit_r24_c38 bl[38] br[38] wl[24] gnd reram_bitcell_7
Xbit_r25_c38 bl[38] br[38] wl[25] gnd reram_bitcell_7
Xbit_r26_c38 bl[38] br[38] wl[26] gnd reram_bitcell_7
Xbit_r27_c38 bl[38] br[38] wl[27] gnd reram_bitcell_7
Xbit_r28_c38 bl[38] br[38] wl[28] gnd reram_bitcell_7
Xbit_r29_c38 bl[38] br[38] wl[29] gnd reram_bitcell_7
Xbit_r30_c38 bl[38] br[38] wl[30] gnd reram_bitcell_7
Xbit_r31_c38 bl[38] br[38] wl[31] gnd reram_bitcell_7
Xbit_r32_c38 bl[38] br[38] wl[32] gnd reram_bitcell_7
Xbit_r33_c38 bl[38] br[38] wl[33] gnd reram_bitcell_7
Xbit_r34_c38 bl[38] br[38] wl[34] gnd reram_bitcell_7
Xbit_r35_c38 bl[38] br[38] wl[35] gnd reram_bitcell_7
Xbit_r36_c38 bl[38] br[38] wl[36] gnd reram_bitcell_7
Xbit_r37_c38 bl[38] br[38] wl[37] gnd reram_bitcell_7
Xbit_r38_c38 bl[38] br[38] wl[38] gnd reram_bitcell_7
Xbit_r39_c38 bl[38] br[38] wl[39] gnd reram_bitcell_7
Xbit_r40_c38 bl[38] br[38] wl[40] gnd reram_bitcell_7
Xbit_r41_c38 bl[38] br[38] wl[41] gnd reram_bitcell_7
Xbit_r42_c38 bl[38] br[38] wl[42] gnd reram_bitcell_7
Xbit_r43_c38 bl[38] br[38] wl[43] gnd reram_bitcell_7
Xbit_r44_c38 bl[38] br[38] wl[44] gnd reram_bitcell_7
Xbit_r45_c38 bl[38] br[38] wl[45] gnd reram_bitcell_7
Xbit_r46_c38 bl[38] br[38] wl[46] gnd reram_bitcell_7
Xbit_r47_c38 bl[38] br[38] wl[47] gnd reram_bitcell_7
Xbit_r48_c38 bl[38] br[38] wl[48] gnd reram_bitcell_7
Xbit_r49_c38 bl[38] br[38] wl[49] gnd reram_bitcell_7
Xbit_r50_c38 bl[38] br[38] wl[50] gnd reram_bitcell_7
Xbit_r51_c38 bl[38] br[38] wl[51] gnd reram_bitcell_7
Xbit_r52_c38 bl[38] br[38] wl[52] gnd reram_bitcell_7
Xbit_r53_c38 bl[38] br[38] wl[53] gnd reram_bitcell_7
Xbit_r54_c38 bl[38] br[38] wl[54] gnd reram_bitcell_7
Xbit_r55_c38 bl[38] br[38] wl[55] gnd reram_bitcell_7
Xbit_r56_c38 bl[38] br[38] wl[56] gnd reram_bitcell_7
Xbit_r57_c38 bl[38] br[38] wl[57] gnd reram_bitcell_7
Xbit_r58_c38 bl[38] br[38] wl[58] gnd reram_bitcell_7
Xbit_r59_c38 bl[38] br[38] wl[59] gnd reram_bitcell_7
Xbit_r60_c38 bl[38] br[38] wl[60] gnd reram_bitcell_7
Xbit_r61_c38 bl[38] br[38] wl[61] gnd reram_bitcell_7
Xbit_r62_c38 bl[38] br[38] wl[62] gnd reram_bitcell_7
Xbit_r63_c38 bl[38] br[38] wl[63] gnd reram_bitcell_7
Xbit_r0_c39 bl[39] br[39] wl[0] gnd reram_bitcell_7
Xbit_r1_c39 bl[39] br[39] wl[1] gnd reram_bitcell_7
Xbit_r2_c39 bl[39] br[39] wl[2] gnd reram_bitcell_7
Xbit_r3_c39 bl[39] br[39] wl[3] gnd reram_bitcell_7
Xbit_r4_c39 bl[39] br[39] wl[4] gnd reram_bitcell_7
Xbit_r5_c39 bl[39] br[39] wl[5] gnd reram_bitcell_7
Xbit_r6_c39 bl[39] br[39] wl[6] gnd reram_bitcell_7
Xbit_r7_c39 bl[39] br[39] wl[7] gnd reram_bitcell_7
Xbit_r8_c39 bl[39] br[39] wl[8] gnd reram_bitcell_7
Xbit_r9_c39 bl[39] br[39] wl[9] gnd reram_bitcell_7
Xbit_r10_c39 bl[39] br[39] wl[10] gnd reram_bitcell_7
Xbit_r11_c39 bl[39] br[39] wl[11] gnd reram_bitcell_7
Xbit_r12_c39 bl[39] br[39] wl[12] gnd reram_bitcell_7
Xbit_r13_c39 bl[39] br[39] wl[13] gnd reram_bitcell_7
Xbit_r14_c39 bl[39] br[39] wl[14] gnd reram_bitcell_7
Xbit_r15_c39 bl[39] br[39] wl[15] gnd reram_bitcell_7
Xbit_r16_c39 bl[39] br[39] wl[16] gnd reram_bitcell_7
Xbit_r17_c39 bl[39] br[39] wl[17] gnd reram_bitcell_7
Xbit_r18_c39 bl[39] br[39] wl[18] gnd reram_bitcell_7
Xbit_r19_c39 bl[39] br[39] wl[19] gnd reram_bitcell_7
Xbit_r20_c39 bl[39] br[39] wl[20] gnd reram_bitcell_7
Xbit_r21_c39 bl[39] br[39] wl[21] gnd reram_bitcell_7
Xbit_r22_c39 bl[39] br[39] wl[22] gnd reram_bitcell_7
Xbit_r23_c39 bl[39] br[39] wl[23] gnd reram_bitcell_7
Xbit_r24_c39 bl[39] br[39] wl[24] gnd reram_bitcell_7
Xbit_r25_c39 bl[39] br[39] wl[25] gnd reram_bitcell_7
Xbit_r26_c39 bl[39] br[39] wl[26] gnd reram_bitcell_7
Xbit_r27_c39 bl[39] br[39] wl[27] gnd reram_bitcell_7
Xbit_r28_c39 bl[39] br[39] wl[28] gnd reram_bitcell_7
Xbit_r29_c39 bl[39] br[39] wl[29] gnd reram_bitcell_7
Xbit_r30_c39 bl[39] br[39] wl[30] gnd reram_bitcell_7
Xbit_r31_c39 bl[39] br[39] wl[31] gnd reram_bitcell_7
Xbit_r32_c39 bl[39] br[39] wl[32] gnd reram_bitcell_7
Xbit_r33_c39 bl[39] br[39] wl[33] gnd reram_bitcell_7
Xbit_r34_c39 bl[39] br[39] wl[34] gnd reram_bitcell_7
Xbit_r35_c39 bl[39] br[39] wl[35] gnd reram_bitcell_7
Xbit_r36_c39 bl[39] br[39] wl[36] gnd reram_bitcell_7
Xbit_r37_c39 bl[39] br[39] wl[37] gnd reram_bitcell_7
Xbit_r38_c39 bl[39] br[39] wl[38] gnd reram_bitcell_7
Xbit_r39_c39 bl[39] br[39] wl[39] gnd reram_bitcell_7
Xbit_r40_c39 bl[39] br[39] wl[40] gnd reram_bitcell_7
Xbit_r41_c39 bl[39] br[39] wl[41] gnd reram_bitcell_7
Xbit_r42_c39 bl[39] br[39] wl[42] gnd reram_bitcell_7
Xbit_r43_c39 bl[39] br[39] wl[43] gnd reram_bitcell_7
Xbit_r44_c39 bl[39] br[39] wl[44] gnd reram_bitcell_7
Xbit_r45_c39 bl[39] br[39] wl[45] gnd reram_bitcell_7
Xbit_r46_c39 bl[39] br[39] wl[46] gnd reram_bitcell_7
Xbit_r47_c39 bl[39] br[39] wl[47] gnd reram_bitcell_7
Xbit_r48_c39 bl[39] br[39] wl[48] gnd reram_bitcell_7
Xbit_r49_c39 bl[39] br[39] wl[49] gnd reram_bitcell_7
Xbit_r50_c39 bl[39] br[39] wl[50] gnd reram_bitcell_7
Xbit_r51_c39 bl[39] br[39] wl[51] gnd reram_bitcell_7
Xbit_r52_c39 bl[39] br[39] wl[52] gnd reram_bitcell_7
Xbit_r53_c39 bl[39] br[39] wl[53] gnd reram_bitcell_7
Xbit_r54_c39 bl[39] br[39] wl[54] gnd reram_bitcell_7
Xbit_r55_c39 bl[39] br[39] wl[55] gnd reram_bitcell_7
Xbit_r56_c39 bl[39] br[39] wl[56] gnd reram_bitcell_7
Xbit_r57_c39 bl[39] br[39] wl[57] gnd reram_bitcell_7
Xbit_r58_c39 bl[39] br[39] wl[58] gnd reram_bitcell_7
Xbit_r59_c39 bl[39] br[39] wl[59] gnd reram_bitcell_7
Xbit_r60_c39 bl[39] br[39] wl[60] gnd reram_bitcell_7
Xbit_r61_c39 bl[39] br[39] wl[61] gnd reram_bitcell_7
Xbit_r62_c39 bl[39] br[39] wl[62] gnd reram_bitcell_7
Xbit_r63_c39 bl[39] br[39] wl[63] gnd reram_bitcell_7
Xbit_r0_c40 bl[40] br[40] wl[0] gnd reram_bitcell_7
Xbit_r1_c40 bl[40] br[40] wl[1] gnd reram_bitcell_7
Xbit_r2_c40 bl[40] br[40] wl[2] gnd reram_bitcell_7
Xbit_r3_c40 bl[40] br[40] wl[3] gnd reram_bitcell_7
Xbit_r4_c40 bl[40] br[40] wl[4] gnd reram_bitcell_7
Xbit_r5_c40 bl[40] br[40] wl[5] gnd reram_bitcell_7
Xbit_r6_c40 bl[40] br[40] wl[6] gnd reram_bitcell_7
Xbit_r7_c40 bl[40] br[40] wl[7] gnd reram_bitcell_7
Xbit_r8_c40 bl[40] br[40] wl[8] gnd reram_bitcell_7
Xbit_r9_c40 bl[40] br[40] wl[9] gnd reram_bitcell_7
Xbit_r10_c40 bl[40] br[40] wl[10] gnd reram_bitcell_7
Xbit_r11_c40 bl[40] br[40] wl[11] gnd reram_bitcell_7
Xbit_r12_c40 bl[40] br[40] wl[12] gnd reram_bitcell_7
Xbit_r13_c40 bl[40] br[40] wl[13] gnd reram_bitcell_7
Xbit_r14_c40 bl[40] br[40] wl[14] gnd reram_bitcell_7
Xbit_r15_c40 bl[40] br[40] wl[15] gnd reram_bitcell_7
Xbit_r16_c40 bl[40] br[40] wl[16] gnd reram_bitcell_7
Xbit_r17_c40 bl[40] br[40] wl[17] gnd reram_bitcell_7
Xbit_r18_c40 bl[40] br[40] wl[18] gnd reram_bitcell_7
Xbit_r19_c40 bl[40] br[40] wl[19] gnd reram_bitcell_7
Xbit_r20_c40 bl[40] br[40] wl[20] gnd reram_bitcell_7
Xbit_r21_c40 bl[40] br[40] wl[21] gnd reram_bitcell_7
Xbit_r22_c40 bl[40] br[40] wl[22] gnd reram_bitcell_7
Xbit_r23_c40 bl[40] br[40] wl[23] gnd reram_bitcell_7
Xbit_r24_c40 bl[40] br[40] wl[24] gnd reram_bitcell_7
Xbit_r25_c40 bl[40] br[40] wl[25] gnd reram_bitcell_7
Xbit_r26_c40 bl[40] br[40] wl[26] gnd reram_bitcell_7
Xbit_r27_c40 bl[40] br[40] wl[27] gnd reram_bitcell_7
Xbit_r28_c40 bl[40] br[40] wl[28] gnd reram_bitcell_7
Xbit_r29_c40 bl[40] br[40] wl[29] gnd reram_bitcell_7
Xbit_r30_c40 bl[40] br[40] wl[30] gnd reram_bitcell_7
Xbit_r31_c40 bl[40] br[40] wl[31] gnd reram_bitcell_7
Xbit_r32_c40 bl[40] br[40] wl[32] gnd reram_bitcell_7
Xbit_r33_c40 bl[40] br[40] wl[33] gnd reram_bitcell_7
Xbit_r34_c40 bl[40] br[40] wl[34] gnd reram_bitcell_7
Xbit_r35_c40 bl[40] br[40] wl[35] gnd reram_bitcell_7
Xbit_r36_c40 bl[40] br[40] wl[36] gnd reram_bitcell_7
Xbit_r37_c40 bl[40] br[40] wl[37] gnd reram_bitcell_7
Xbit_r38_c40 bl[40] br[40] wl[38] gnd reram_bitcell_7
Xbit_r39_c40 bl[40] br[40] wl[39] gnd reram_bitcell_7
Xbit_r40_c40 bl[40] br[40] wl[40] gnd reram_bitcell_7
Xbit_r41_c40 bl[40] br[40] wl[41] gnd reram_bitcell_7
Xbit_r42_c40 bl[40] br[40] wl[42] gnd reram_bitcell_7
Xbit_r43_c40 bl[40] br[40] wl[43] gnd reram_bitcell_7
Xbit_r44_c40 bl[40] br[40] wl[44] gnd reram_bitcell_7
Xbit_r45_c40 bl[40] br[40] wl[45] gnd reram_bitcell_7
Xbit_r46_c40 bl[40] br[40] wl[46] gnd reram_bitcell_7
Xbit_r47_c40 bl[40] br[40] wl[47] gnd reram_bitcell_7
Xbit_r48_c40 bl[40] br[40] wl[48] gnd reram_bitcell_7
Xbit_r49_c40 bl[40] br[40] wl[49] gnd reram_bitcell_7
Xbit_r50_c40 bl[40] br[40] wl[50] gnd reram_bitcell_7
Xbit_r51_c40 bl[40] br[40] wl[51] gnd reram_bitcell_7
Xbit_r52_c40 bl[40] br[40] wl[52] gnd reram_bitcell_7
Xbit_r53_c40 bl[40] br[40] wl[53] gnd reram_bitcell_7
Xbit_r54_c40 bl[40] br[40] wl[54] gnd reram_bitcell_7
Xbit_r55_c40 bl[40] br[40] wl[55] gnd reram_bitcell_7
Xbit_r56_c40 bl[40] br[40] wl[56] gnd reram_bitcell_7
Xbit_r57_c40 bl[40] br[40] wl[57] gnd reram_bitcell_7
Xbit_r58_c40 bl[40] br[40] wl[58] gnd reram_bitcell_7
Xbit_r59_c40 bl[40] br[40] wl[59] gnd reram_bitcell_7
Xbit_r60_c40 bl[40] br[40] wl[60] gnd reram_bitcell_7
Xbit_r61_c40 bl[40] br[40] wl[61] gnd reram_bitcell_7
Xbit_r62_c40 bl[40] br[40] wl[62] gnd reram_bitcell_7
Xbit_r63_c40 bl[40] br[40] wl[63] gnd reram_bitcell_7
Xbit_r0_c41 bl[41] br[41] wl[0] gnd reram_bitcell_7
Xbit_r1_c41 bl[41] br[41] wl[1] gnd reram_bitcell_7
Xbit_r2_c41 bl[41] br[41] wl[2] gnd reram_bitcell_7
Xbit_r3_c41 bl[41] br[41] wl[3] gnd reram_bitcell_7
Xbit_r4_c41 bl[41] br[41] wl[4] gnd reram_bitcell_7
Xbit_r5_c41 bl[41] br[41] wl[5] gnd reram_bitcell_7
Xbit_r6_c41 bl[41] br[41] wl[6] gnd reram_bitcell_7
Xbit_r7_c41 bl[41] br[41] wl[7] gnd reram_bitcell_7
Xbit_r8_c41 bl[41] br[41] wl[8] gnd reram_bitcell_7
Xbit_r9_c41 bl[41] br[41] wl[9] gnd reram_bitcell_7
Xbit_r10_c41 bl[41] br[41] wl[10] gnd reram_bitcell_7
Xbit_r11_c41 bl[41] br[41] wl[11] gnd reram_bitcell_7
Xbit_r12_c41 bl[41] br[41] wl[12] gnd reram_bitcell_7
Xbit_r13_c41 bl[41] br[41] wl[13] gnd reram_bitcell_7
Xbit_r14_c41 bl[41] br[41] wl[14] gnd reram_bitcell_7
Xbit_r15_c41 bl[41] br[41] wl[15] gnd reram_bitcell_7
Xbit_r16_c41 bl[41] br[41] wl[16] gnd reram_bitcell_7
Xbit_r17_c41 bl[41] br[41] wl[17] gnd reram_bitcell_7
Xbit_r18_c41 bl[41] br[41] wl[18] gnd reram_bitcell_7
Xbit_r19_c41 bl[41] br[41] wl[19] gnd reram_bitcell_7
Xbit_r20_c41 bl[41] br[41] wl[20] gnd reram_bitcell_7
Xbit_r21_c41 bl[41] br[41] wl[21] gnd reram_bitcell_7
Xbit_r22_c41 bl[41] br[41] wl[22] gnd reram_bitcell_7
Xbit_r23_c41 bl[41] br[41] wl[23] gnd reram_bitcell_7
Xbit_r24_c41 bl[41] br[41] wl[24] gnd reram_bitcell_7
Xbit_r25_c41 bl[41] br[41] wl[25] gnd reram_bitcell_7
Xbit_r26_c41 bl[41] br[41] wl[26] gnd reram_bitcell_7
Xbit_r27_c41 bl[41] br[41] wl[27] gnd reram_bitcell_7
Xbit_r28_c41 bl[41] br[41] wl[28] gnd reram_bitcell_7
Xbit_r29_c41 bl[41] br[41] wl[29] gnd reram_bitcell_7
Xbit_r30_c41 bl[41] br[41] wl[30] gnd reram_bitcell_7
Xbit_r31_c41 bl[41] br[41] wl[31] gnd reram_bitcell_7
Xbit_r32_c41 bl[41] br[41] wl[32] gnd reram_bitcell_7
Xbit_r33_c41 bl[41] br[41] wl[33] gnd reram_bitcell_7
Xbit_r34_c41 bl[41] br[41] wl[34] gnd reram_bitcell_7
Xbit_r35_c41 bl[41] br[41] wl[35] gnd reram_bitcell_7
Xbit_r36_c41 bl[41] br[41] wl[36] gnd reram_bitcell_7
Xbit_r37_c41 bl[41] br[41] wl[37] gnd reram_bitcell_7
Xbit_r38_c41 bl[41] br[41] wl[38] gnd reram_bitcell_7
Xbit_r39_c41 bl[41] br[41] wl[39] gnd reram_bitcell_7
Xbit_r40_c41 bl[41] br[41] wl[40] gnd reram_bitcell_7
Xbit_r41_c41 bl[41] br[41] wl[41] gnd reram_bitcell_7
Xbit_r42_c41 bl[41] br[41] wl[42] gnd reram_bitcell_7
Xbit_r43_c41 bl[41] br[41] wl[43] gnd reram_bitcell_7
Xbit_r44_c41 bl[41] br[41] wl[44] gnd reram_bitcell_7
Xbit_r45_c41 bl[41] br[41] wl[45] gnd reram_bitcell_7
Xbit_r46_c41 bl[41] br[41] wl[46] gnd reram_bitcell_7
Xbit_r47_c41 bl[41] br[41] wl[47] gnd reram_bitcell_7
Xbit_r48_c41 bl[41] br[41] wl[48] gnd reram_bitcell_7
Xbit_r49_c41 bl[41] br[41] wl[49] gnd reram_bitcell_7
Xbit_r50_c41 bl[41] br[41] wl[50] gnd reram_bitcell_7
Xbit_r51_c41 bl[41] br[41] wl[51] gnd reram_bitcell_7
Xbit_r52_c41 bl[41] br[41] wl[52] gnd reram_bitcell_7
Xbit_r53_c41 bl[41] br[41] wl[53] gnd reram_bitcell_7
Xbit_r54_c41 bl[41] br[41] wl[54] gnd reram_bitcell_7
Xbit_r55_c41 bl[41] br[41] wl[55] gnd reram_bitcell_7
Xbit_r56_c41 bl[41] br[41] wl[56] gnd reram_bitcell_7
Xbit_r57_c41 bl[41] br[41] wl[57] gnd reram_bitcell_7
Xbit_r58_c41 bl[41] br[41] wl[58] gnd reram_bitcell_7
Xbit_r59_c41 bl[41] br[41] wl[59] gnd reram_bitcell_7
Xbit_r60_c41 bl[41] br[41] wl[60] gnd reram_bitcell_7
Xbit_r61_c41 bl[41] br[41] wl[61] gnd reram_bitcell_7
Xbit_r62_c41 bl[41] br[41] wl[62] gnd reram_bitcell_7
Xbit_r63_c41 bl[41] br[41] wl[63] gnd reram_bitcell_7
Xbit_r0_c42 bl[42] br[42] wl[0] gnd reram_bitcell_7
Xbit_r1_c42 bl[42] br[42] wl[1] gnd reram_bitcell_7
Xbit_r2_c42 bl[42] br[42] wl[2] gnd reram_bitcell_7
Xbit_r3_c42 bl[42] br[42] wl[3] gnd reram_bitcell_7
Xbit_r4_c42 bl[42] br[42] wl[4] gnd reram_bitcell_7
Xbit_r5_c42 bl[42] br[42] wl[5] gnd reram_bitcell_7
Xbit_r6_c42 bl[42] br[42] wl[6] gnd reram_bitcell_7
Xbit_r7_c42 bl[42] br[42] wl[7] gnd reram_bitcell_7
Xbit_r8_c42 bl[42] br[42] wl[8] gnd reram_bitcell_7
Xbit_r9_c42 bl[42] br[42] wl[9] gnd reram_bitcell_7
Xbit_r10_c42 bl[42] br[42] wl[10] gnd reram_bitcell_7
Xbit_r11_c42 bl[42] br[42] wl[11] gnd reram_bitcell_7
Xbit_r12_c42 bl[42] br[42] wl[12] gnd reram_bitcell_7
Xbit_r13_c42 bl[42] br[42] wl[13] gnd reram_bitcell_7
Xbit_r14_c42 bl[42] br[42] wl[14] gnd reram_bitcell_7
Xbit_r15_c42 bl[42] br[42] wl[15] gnd reram_bitcell_7
Xbit_r16_c42 bl[42] br[42] wl[16] gnd reram_bitcell_7
Xbit_r17_c42 bl[42] br[42] wl[17] gnd reram_bitcell_7
Xbit_r18_c42 bl[42] br[42] wl[18] gnd reram_bitcell_7
Xbit_r19_c42 bl[42] br[42] wl[19] gnd reram_bitcell_7
Xbit_r20_c42 bl[42] br[42] wl[20] gnd reram_bitcell_7
Xbit_r21_c42 bl[42] br[42] wl[21] gnd reram_bitcell_7
Xbit_r22_c42 bl[42] br[42] wl[22] gnd reram_bitcell_7
Xbit_r23_c42 bl[42] br[42] wl[23] gnd reram_bitcell_7
Xbit_r24_c42 bl[42] br[42] wl[24] gnd reram_bitcell_7
Xbit_r25_c42 bl[42] br[42] wl[25] gnd reram_bitcell_7
Xbit_r26_c42 bl[42] br[42] wl[26] gnd reram_bitcell_7
Xbit_r27_c42 bl[42] br[42] wl[27] gnd reram_bitcell_7
Xbit_r28_c42 bl[42] br[42] wl[28] gnd reram_bitcell_7
Xbit_r29_c42 bl[42] br[42] wl[29] gnd reram_bitcell_7
Xbit_r30_c42 bl[42] br[42] wl[30] gnd reram_bitcell_7
Xbit_r31_c42 bl[42] br[42] wl[31] gnd reram_bitcell_7
Xbit_r32_c42 bl[42] br[42] wl[32] gnd reram_bitcell_7
Xbit_r33_c42 bl[42] br[42] wl[33] gnd reram_bitcell_7
Xbit_r34_c42 bl[42] br[42] wl[34] gnd reram_bitcell_7
Xbit_r35_c42 bl[42] br[42] wl[35] gnd reram_bitcell_7
Xbit_r36_c42 bl[42] br[42] wl[36] gnd reram_bitcell_7
Xbit_r37_c42 bl[42] br[42] wl[37] gnd reram_bitcell_7
Xbit_r38_c42 bl[42] br[42] wl[38] gnd reram_bitcell_7
Xbit_r39_c42 bl[42] br[42] wl[39] gnd reram_bitcell_7
Xbit_r40_c42 bl[42] br[42] wl[40] gnd reram_bitcell_7
Xbit_r41_c42 bl[42] br[42] wl[41] gnd reram_bitcell_7
Xbit_r42_c42 bl[42] br[42] wl[42] gnd reram_bitcell_7
Xbit_r43_c42 bl[42] br[42] wl[43] gnd reram_bitcell_7
Xbit_r44_c42 bl[42] br[42] wl[44] gnd reram_bitcell_7
Xbit_r45_c42 bl[42] br[42] wl[45] gnd reram_bitcell_7
Xbit_r46_c42 bl[42] br[42] wl[46] gnd reram_bitcell_7
Xbit_r47_c42 bl[42] br[42] wl[47] gnd reram_bitcell_7
Xbit_r48_c42 bl[42] br[42] wl[48] gnd reram_bitcell_7
Xbit_r49_c42 bl[42] br[42] wl[49] gnd reram_bitcell_7
Xbit_r50_c42 bl[42] br[42] wl[50] gnd reram_bitcell_7
Xbit_r51_c42 bl[42] br[42] wl[51] gnd reram_bitcell_7
Xbit_r52_c42 bl[42] br[42] wl[52] gnd reram_bitcell_7
Xbit_r53_c42 bl[42] br[42] wl[53] gnd reram_bitcell_7
Xbit_r54_c42 bl[42] br[42] wl[54] gnd reram_bitcell_7
Xbit_r55_c42 bl[42] br[42] wl[55] gnd reram_bitcell_7
Xbit_r56_c42 bl[42] br[42] wl[56] gnd reram_bitcell_7
Xbit_r57_c42 bl[42] br[42] wl[57] gnd reram_bitcell_7
Xbit_r58_c42 bl[42] br[42] wl[58] gnd reram_bitcell_7
Xbit_r59_c42 bl[42] br[42] wl[59] gnd reram_bitcell_7
Xbit_r60_c42 bl[42] br[42] wl[60] gnd reram_bitcell_7
Xbit_r61_c42 bl[42] br[42] wl[61] gnd reram_bitcell_7
Xbit_r62_c42 bl[42] br[42] wl[62] gnd reram_bitcell_7
Xbit_r63_c42 bl[42] br[42] wl[63] gnd reram_bitcell_7
Xbit_r0_c43 bl[43] br[43] wl[0] gnd reram_bitcell_7
Xbit_r1_c43 bl[43] br[43] wl[1] gnd reram_bitcell_7
Xbit_r2_c43 bl[43] br[43] wl[2] gnd reram_bitcell_7
Xbit_r3_c43 bl[43] br[43] wl[3] gnd reram_bitcell_7
Xbit_r4_c43 bl[43] br[43] wl[4] gnd reram_bitcell_7
Xbit_r5_c43 bl[43] br[43] wl[5] gnd reram_bitcell_7
Xbit_r6_c43 bl[43] br[43] wl[6] gnd reram_bitcell_7
Xbit_r7_c43 bl[43] br[43] wl[7] gnd reram_bitcell_7
Xbit_r8_c43 bl[43] br[43] wl[8] gnd reram_bitcell_7
Xbit_r9_c43 bl[43] br[43] wl[9] gnd reram_bitcell_7
Xbit_r10_c43 bl[43] br[43] wl[10] gnd reram_bitcell_7
Xbit_r11_c43 bl[43] br[43] wl[11] gnd reram_bitcell_7
Xbit_r12_c43 bl[43] br[43] wl[12] gnd reram_bitcell_7
Xbit_r13_c43 bl[43] br[43] wl[13] gnd reram_bitcell_7
Xbit_r14_c43 bl[43] br[43] wl[14] gnd reram_bitcell_7
Xbit_r15_c43 bl[43] br[43] wl[15] gnd reram_bitcell_7
Xbit_r16_c43 bl[43] br[43] wl[16] gnd reram_bitcell_7
Xbit_r17_c43 bl[43] br[43] wl[17] gnd reram_bitcell_7
Xbit_r18_c43 bl[43] br[43] wl[18] gnd reram_bitcell_7
Xbit_r19_c43 bl[43] br[43] wl[19] gnd reram_bitcell_7
Xbit_r20_c43 bl[43] br[43] wl[20] gnd reram_bitcell_7
Xbit_r21_c43 bl[43] br[43] wl[21] gnd reram_bitcell_7
Xbit_r22_c43 bl[43] br[43] wl[22] gnd reram_bitcell_7
Xbit_r23_c43 bl[43] br[43] wl[23] gnd reram_bitcell_7
Xbit_r24_c43 bl[43] br[43] wl[24] gnd reram_bitcell_7
Xbit_r25_c43 bl[43] br[43] wl[25] gnd reram_bitcell_7
Xbit_r26_c43 bl[43] br[43] wl[26] gnd reram_bitcell_7
Xbit_r27_c43 bl[43] br[43] wl[27] gnd reram_bitcell_7
Xbit_r28_c43 bl[43] br[43] wl[28] gnd reram_bitcell_7
Xbit_r29_c43 bl[43] br[43] wl[29] gnd reram_bitcell_7
Xbit_r30_c43 bl[43] br[43] wl[30] gnd reram_bitcell_7
Xbit_r31_c43 bl[43] br[43] wl[31] gnd reram_bitcell_7
Xbit_r32_c43 bl[43] br[43] wl[32] gnd reram_bitcell_7
Xbit_r33_c43 bl[43] br[43] wl[33] gnd reram_bitcell_7
Xbit_r34_c43 bl[43] br[43] wl[34] gnd reram_bitcell_7
Xbit_r35_c43 bl[43] br[43] wl[35] gnd reram_bitcell_7
Xbit_r36_c43 bl[43] br[43] wl[36] gnd reram_bitcell_7
Xbit_r37_c43 bl[43] br[43] wl[37] gnd reram_bitcell_7
Xbit_r38_c43 bl[43] br[43] wl[38] gnd reram_bitcell_7
Xbit_r39_c43 bl[43] br[43] wl[39] gnd reram_bitcell_7
Xbit_r40_c43 bl[43] br[43] wl[40] gnd reram_bitcell_7
Xbit_r41_c43 bl[43] br[43] wl[41] gnd reram_bitcell_7
Xbit_r42_c43 bl[43] br[43] wl[42] gnd reram_bitcell_7
Xbit_r43_c43 bl[43] br[43] wl[43] gnd reram_bitcell_7
Xbit_r44_c43 bl[43] br[43] wl[44] gnd reram_bitcell_7
Xbit_r45_c43 bl[43] br[43] wl[45] gnd reram_bitcell_7
Xbit_r46_c43 bl[43] br[43] wl[46] gnd reram_bitcell_7
Xbit_r47_c43 bl[43] br[43] wl[47] gnd reram_bitcell_7
Xbit_r48_c43 bl[43] br[43] wl[48] gnd reram_bitcell_7
Xbit_r49_c43 bl[43] br[43] wl[49] gnd reram_bitcell_7
Xbit_r50_c43 bl[43] br[43] wl[50] gnd reram_bitcell_7
Xbit_r51_c43 bl[43] br[43] wl[51] gnd reram_bitcell_7
Xbit_r52_c43 bl[43] br[43] wl[52] gnd reram_bitcell_7
Xbit_r53_c43 bl[43] br[43] wl[53] gnd reram_bitcell_7
Xbit_r54_c43 bl[43] br[43] wl[54] gnd reram_bitcell_7
Xbit_r55_c43 bl[43] br[43] wl[55] gnd reram_bitcell_7
Xbit_r56_c43 bl[43] br[43] wl[56] gnd reram_bitcell_7
Xbit_r57_c43 bl[43] br[43] wl[57] gnd reram_bitcell_7
Xbit_r58_c43 bl[43] br[43] wl[58] gnd reram_bitcell_7
Xbit_r59_c43 bl[43] br[43] wl[59] gnd reram_bitcell_7
Xbit_r60_c43 bl[43] br[43] wl[60] gnd reram_bitcell_7
Xbit_r61_c43 bl[43] br[43] wl[61] gnd reram_bitcell_7
Xbit_r62_c43 bl[43] br[43] wl[62] gnd reram_bitcell_7
Xbit_r63_c43 bl[43] br[43] wl[63] gnd reram_bitcell_7
Xbit_r0_c44 bl[44] br[44] wl[0] gnd reram_bitcell_7
Xbit_r1_c44 bl[44] br[44] wl[1] gnd reram_bitcell_7
Xbit_r2_c44 bl[44] br[44] wl[2] gnd reram_bitcell_7
Xbit_r3_c44 bl[44] br[44] wl[3] gnd reram_bitcell_7
Xbit_r4_c44 bl[44] br[44] wl[4] gnd reram_bitcell_7
Xbit_r5_c44 bl[44] br[44] wl[5] gnd reram_bitcell_7
Xbit_r6_c44 bl[44] br[44] wl[6] gnd reram_bitcell_7
Xbit_r7_c44 bl[44] br[44] wl[7] gnd reram_bitcell_7
Xbit_r8_c44 bl[44] br[44] wl[8] gnd reram_bitcell_7
Xbit_r9_c44 bl[44] br[44] wl[9] gnd reram_bitcell_7
Xbit_r10_c44 bl[44] br[44] wl[10] gnd reram_bitcell_7
Xbit_r11_c44 bl[44] br[44] wl[11] gnd reram_bitcell_7
Xbit_r12_c44 bl[44] br[44] wl[12] gnd reram_bitcell_7
Xbit_r13_c44 bl[44] br[44] wl[13] gnd reram_bitcell_7
Xbit_r14_c44 bl[44] br[44] wl[14] gnd reram_bitcell_7
Xbit_r15_c44 bl[44] br[44] wl[15] gnd reram_bitcell_7
Xbit_r16_c44 bl[44] br[44] wl[16] gnd reram_bitcell_7
Xbit_r17_c44 bl[44] br[44] wl[17] gnd reram_bitcell_7
Xbit_r18_c44 bl[44] br[44] wl[18] gnd reram_bitcell_7
Xbit_r19_c44 bl[44] br[44] wl[19] gnd reram_bitcell_7
Xbit_r20_c44 bl[44] br[44] wl[20] gnd reram_bitcell_7
Xbit_r21_c44 bl[44] br[44] wl[21] gnd reram_bitcell_7
Xbit_r22_c44 bl[44] br[44] wl[22] gnd reram_bitcell_7
Xbit_r23_c44 bl[44] br[44] wl[23] gnd reram_bitcell_7
Xbit_r24_c44 bl[44] br[44] wl[24] gnd reram_bitcell_7
Xbit_r25_c44 bl[44] br[44] wl[25] gnd reram_bitcell_7
Xbit_r26_c44 bl[44] br[44] wl[26] gnd reram_bitcell_7
Xbit_r27_c44 bl[44] br[44] wl[27] gnd reram_bitcell_7
Xbit_r28_c44 bl[44] br[44] wl[28] gnd reram_bitcell_7
Xbit_r29_c44 bl[44] br[44] wl[29] gnd reram_bitcell_7
Xbit_r30_c44 bl[44] br[44] wl[30] gnd reram_bitcell_7
Xbit_r31_c44 bl[44] br[44] wl[31] gnd reram_bitcell_7
Xbit_r32_c44 bl[44] br[44] wl[32] gnd reram_bitcell_7
Xbit_r33_c44 bl[44] br[44] wl[33] gnd reram_bitcell_7
Xbit_r34_c44 bl[44] br[44] wl[34] gnd reram_bitcell_7
Xbit_r35_c44 bl[44] br[44] wl[35] gnd reram_bitcell_7
Xbit_r36_c44 bl[44] br[44] wl[36] gnd reram_bitcell_7
Xbit_r37_c44 bl[44] br[44] wl[37] gnd reram_bitcell_7
Xbit_r38_c44 bl[44] br[44] wl[38] gnd reram_bitcell_7
Xbit_r39_c44 bl[44] br[44] wl[39] gnd reram_bitcell_7
Xbit_r40_c44 bl[44] br[44] wl[40] gnd reram_bitcell_7
Xbit_r41_c44 bl[44] br[44] wl[41] gnd reram_bitcell_7
Xbit_r42_c44 bl[44] br[44] wl[42] gnd reram_bitcell_7
Xbit_r43_c44 bl[44] br[44] wl[43] gnd reram_bitcell_7
Xbit_r44_c44 bl[44] br[44] wl[44] gnd reram_bitcell_7
Xbit_r45_c44 bl[44] br[44] wl[45] gnd reram_bitcell_7
Xbit_r46_c44 bl[44] br[44] wl[46] gnd reram_bitcell_7
Xbit_r47_c44 bl[44] br[44] wl[47] gnd reram_bitcell_7
Xbit_r48_c44 bl[44] br[44] wl[48] gnd reram_bitcell_7
Xbit_r49_c44 bl[44] br[44] wl[49] gnd reram_bitcell_7
Xbit_r50_c44 bl[44] br[44] wl[50] gnd reram_bitcell_7
Xbit_r51_c44 bl[44] br[44] wl[51] gnd reram_bitcell_7
Xbit_r52_c44 bl[44] br[44] wl[52] gnd reram_bitcell_7
Xbit_r53_c44 bl[44] br[44] wl[53] gnd reram_bitcell_7
Xbit_r54_c44 bl[44] br[44] wl[54] gnd reram_bitcell_7
Xbit_r55_c44 bl[44] br[44] wl[55] gnd reram_bitcell_7
Xbit_r56_c44 bl[44] br[44] wl[56] gnd reram_bitcell_7
Xbit_r57_c44 bl[44] br[44] wl[57] gnd reram_bitcell_7
Xbit_r58_c44 bl[44] br[44] wl[58] gnd reram_bitcell_7
Xbit_r59_c44 bl[44] br[44] wl[59] gnd reram_bitcell_7
Xbit_r60_c44 bl[44] br[44] wl[60] gnd reram_bitcell_7
Xbit_r61_c44 bl[44] br[44] wl[61] gnd reram_bitcell_7
Xbit_r62_c44 bl[44] br[44] wl[62] gnd reram_bitcell_7
Xbit_r63_c44 bl[44] br[44] wl[63] gnd reram_bitcell_7
Xbit_r0_c45 bl[45] br[45] wl[0] gnd reram_bitcell_7
Xbit_r1_c45 bl[45] br[45] wl[1] gnd reram_bitcell_7
Xbit_r2_c45 bl[45] br[45] wl[2] gnd reram_bitcell_7
Xbit_r3_c45 bl[45] br[45] wl[3] gnd reram_bitcell_7
Xbit_r4_c45 bl[45] br[45] wl[4] gnd reram_bitcell_7
Xbit_r5_c45 bl[45] br[45] wl[5] gnd reram_bitcell_7
Xbit_r6_c45 bl[45] br[45] wl[6] gnd reram_bitcell_7
Xbit_r7_c45 bl[45] br[45] wl[7] gnd reram_bitcell_7
Xbit_r8_c45 bl[45] br[45] wl[8] gnd reram_bitcell_7
Xbit_r9_c45 bl[45] br[45] wl[9] gnd reram_bitcell_7
Xbit_r10_c45 bl[45] br[45] wl[10] gnd reram_bitcell_7
Xbit_r11_c45 bl[45] br[45] wl[11] gnd reram_bitcell_7
Xbit_r12_c45 bl[45] br[45] wl[12] gnd reram_bitcell_7
Xbit_r13_c45 bl[45] br[45] wl[13] gnd reram_bitcell_7
Xbit_r14_c45 bl[45] br[45] wl[14] gnd reram_bitcell_7
Xbit_r15_c45 bl[45] br[45] wl[15] gnd reram_bitcell_7
Xbit_r16_c45 bl[45] br[45] wl[16] gnd reram_bitcell_7
Xbit_r17_c45 bl[45] br[45] wl[17] gnd reram_bitcell_7
Xbit_r18_c45 bl[45] br[45] wl[18] gnd reram_bitcell_7
Xbit_r19_c45 bl[45] br[45] wl[19] gnd reram_bitcell_7
Xbit_r20_c45 bl[45] br[45] wl[20] gnd reram_bitcell_7
Xbit_r21_c45 bl[45] br[45] wl[21] gnd reram_bitcell_7
Xbit_r22_c45 bl[45] br[45] wl[22] gnd reram_bitcell_7
Xbit_r23_c45 bl[45] br[45] wl[23] gnd reram_bitcell_7
Xbit_r24_c45 bl[45] br[45] wl[24] gnd reram_bitcell_7
Xbit_r25_c45 bl[45] br[45] wl[25] gnd reram_bitcell_7
Xbit_r26_c45 bl[45] br[45] wl[26] gnd reram_bitcell_7
Xbit_r27_c45 bl[45] br[45] wl[27] gnd reram_bitcell_7
Xbit_r28_c45 bl[45] br[45] wl[28] gnd reram_bitcell_7
Xbit_r29_c45 bl[45] br[45] wl[29] gnd reram_bitcell_7
Xbit_r30_c45 bl[45] br[45] wl[30] gnd reram_bitcell_7
Xbit_r31_c45 bl[45] br[45] wl[31] gnd reram_bitcell_7
Xbit_r32_c45 bl[45] br[45] wl[32] gnd reram_bitcell_7
Xbit_r33_c45 bl[45] br[45] wl[33] gnd reram_bitcell_7
Xbit_r34_c45 bl[45] br[45] wl[34] gnd reram_bitcell_7
Xbit_r35_c45 bl[45] br[45] wl[35] gnd reram_bitcell_7
Xbit_r36_c45 bl[45] br[45] wl[36] gnd reram_bitcell_7
Xbit_r37_c45 bl[45] br[45] wl[37] gnd reram_bitcell_7
Xbit_r38_c45 bl[45] br[45] wl[38] gnd reram_bitcell_7
Xbit_r39_c45 bl[45] br[45] wl[39] gnd reram_bitcell_7
Xbit_r40_c45 bl[45] br[45] wl[40] gnd reram_bitcell_7
Xbit_r41_c45 bl[45] br[45] wl[41] gnd reram_bitcell_7
Xbit_r42_c45 bl[45] br[45] wl[42] gnd reram_bitcell_7
Xbit_r43_c45 bl[45] br[45] wl[43] gnd reram_bitcell_7
Xbit_r44_c45 bl[45] br[45] wl[44] gnd reram_bitcell_7
Xbit_r45_c45 bl[45] br[45] wl[45] gnd reram_bitcell_7
Xbit_r46_c45 bl[45] br[45] wl[46] gnd reram_bitcell_7
Xbit_r47_c45 bl[45] br[45] wl[47] gnd reram_bitcell_7
Xbit_r48_c45 bl[45] br[45] wl[48] gnd reram_bitcell_7
Xbit_r49_c45 bl[45] br[45] wl[49] gnd reram_bitcell_7
Xbit_r50_c45 bl[45] br[45] wl[50] gnd reram_bitcell_7
Xbit_r51_c45 bl[45] br[45] wl[51] gnd reram_bitcell_7
Xbit_r52_c45 bl[45] br[45] wl[52] gnd reram_bitcell_7
Xbit_r53_c45 bl[45] br[45] wl[53] gnd reram_bitcell_7
Xbit_r54_c45 bl[45] br[45] wl[54] gnd reram_bitcell_7
Xbit_r55_c45 bl[45] br[45] wl[55] gnd reram_bitcell_7
Xbit_r56_c45 bl[45] br[45] wl[56] gnd reram_bitcell_7
Xbit_r57_c45 bl[45] br[45] wl[57] gnd reram_bitcell_7
Xbit_r58_c45 bl[45] br[45] wl[58] gnd reram_bitcell_7
Xbit_r59_c45 bl[45] br[45] wl[59] gnd reram_bitcell_7
Xbit_r60_c45 bl[45] br[45] wl[60] gnd reram_bitcell_7
Xbit_r61_c45 bl[45] br[45] wl[61] gnd reram_bitcell_7
Xbit_r62_c45 bl[45] br[45] wl[62] gnd reram_bitcell_7
Xbit_r63_c45 bl[45] br[45] wl[63] gnd reram_bitcell_7
Xbit_r0_c46 bl[46] br[46] wl[0] gnd reram_bitcell_7
Xbit_r1_c46 bl[46] br[46] wl[1] gnd reram_bitcell_7
Xbit_r2_c46 bl[46] br[46] wl[2] gnd reram_bitcell_7
Xbit_r3_c46 bl[46] br[46] wl[3] gnd reram_bitcell_7
Xbit_r4_c46 bl[46] br[46] wl[4] gnd reram_bitcell_7
Xbit_r5_c46 bl[46] br[46] wl[5] gnd reram_bitcell_7
Xbit_r6_c46 bl[46] br[46] wl[6] gnd reram_bitcell_7
Xbit_r7_c46 bl[46] br[46] wl[7] gnd reram_bitcell_7
Xbit_r8_c46 bl[46] br[46] wl[8] gnd reram_bitcell_7
Xbit_r9_c46 bl[46] br[46] wl[9] gnd reram_bitcell_7
Xbit_r10_c46 bl[46] br[46] wl[10] gnd reram_bitcell_7
Xbit_r11_c46 bl[46] br[46] wl[11] gnd reram_bitcell_7
Xbit_r12_c46 bl[46] br[46] wl[12] gnd reram_bitcell_7
Xbit_r13_c46 bl[46] br[46] wl[13] gnd reram_bitcell_7
Xbit_r14_c46 bl[46] br[46] wl[14] gnd reram_bitcell_7
Xbit_r15_c46 bl[46] br[46] wl[15] gnd reram_bitcell_7
Xbit_r16_c46 bl[46] br[46] wl[16] gnd reram_bitcell_7
Xbit_r17_c46 bl[46] br[46] wl[17] gnd reram_bitcell_7
Xbit_r18_c46 bl[46] br[46] wl[18] gnd reram_bitcell_7
Xbit_r19_c46 bl[46] br[46] wl[19] gnd reram_bitcell_7
Xbit_r20_c46 bl[46] br[46] wl[20] gnd reram_bitcell_7
Xbit_r21_c46 bl[46] br[46] wl[21] gnd reram_bitcell_7
Xbit_r22_c46 bl[46] br[46] wl[22] gnd reram_bitcell_7
Xbit_r23_c46 bl[46] br[46] wl[23] gnd reram_bitcell_7
Xbit_r24_c46 bl[46] br[46] wl[24] gnd reram_bitcell_7
Xbit_r25_c46 bl[46] br[46] wl[25] gnd reram_bitcell_7
Xbit_r26_c46 bl[46] br[46] wl[26] gnd reram_bitcell_7
Xbit_r27_c46 bl[46] br[46] wl[27] gnd reram_bitcell_7
Xbit_r28_c46 bl[46] br[46] wl[28] gnd reram_bitcell_7
Xbit_r29_c46 bl[46] br[46] wl[29] gnd reram_bitcell_7
Xbit_r30_c46 bl[46] br[46] wl[30] gnd reram_bitcell_7
Xbit_r31_c46 bl[46] br[46] wl[31] gnd reram_bitcell_7
Xbit_r32_c46 bl[46] br[46] wl[32] gnd reram_bitcell_7
Xbit_r33_c46 bl[46] br[46] wl[33] gnd reram_bitcell_7
Xbit_r34_c46 bl[46] br[46] wl[34] gnd reram_bitcell_7
Xbit_r35_c46 bl[46] br[46] wl[35] gnd reram_bitcell_7
Xbit_r36_c46 bl[46] br[46] wl[36] gnd reram_bitcell_7
Xbit_r37_c46 bl[46] br[46] wl[37] gnd reram_bitcell_7
Xbit_r38_c46 bl[46] br[46] wl[38] gnd reram_bitcell_7
Xbit_r39_c46 bl[46] br[46] wl[39] gnd reram_bitcell_7
Xbit_r40_c46 bl[46] br[46] wl[40] gnd reram_bitcell_7
Xbit_r41_c46 bl[46] br[46] wl[41] gnd reram_bitcell_7
Xbit_r42_c46 bl[46] br[46] wl[42] gnd reram_bitcell_7
Xbit_r43_c46 bl[46] br[46] wl[43] gnd reram_bitcell_7
Xbit_r44_c46 bl[46] br[46] wl[44] gnd reram_bitcell_7
Xbit_r45_c46 bl[46] br[46] wl[45] gnd reram_bitcell_7
Xbit_r46_c46 bl[46] br[46] wl[46] gnd reram_bitcell_7
Xbit_r47_c46 bl[46] br[46] wl[47] gnd reram_bitcell_7
Xbit_r48_c46 bl[46] br[46] wl[48] gnd reram_bitcell_7
Xbit_r49_c46 bl[46] br[46] wl[49] gnd reram_bitcell_7
Xbit_r50_c46 bl[46] br[46] wl[50] gnd reram_bitcell_7
Xbit_r51_c46 bl[46] br[46] wl[51] gnd reram_bitcell_7
Xbit_r52_c46 bl[46] br[46] wl[52] gnd reram_bitcell_7
Xbit_r53_c46 bl[46] br[46] wl[53] gnd reram_bitcell_7
Xbit_r54_c46 bl[46] br[46] wl[54] gnd reram_bitcell_7
Xbit_r55_c46 bl[46] br[46] wl[55] gnd reram_bitcell_7
Xbit_r56_c46 bl[46] br[46] wl[56] gnd reram_bitcell_7
Xbit_r57_c46 bl[46] br[46] wl[57] gnd reram_bitcell_7
Xbit_r58_c46 bl[46] br[46] wl[58] gnd reram_bitcell_7
Xbit_r59_c46 bl[46] br[46] wl[59] gnd reram_bitcell_7
Xbit_r60_c46 bl[46] br[46] wl[60] gnd reram_bitcell_7
Xbit_r61_c46 bl[46] br[46] wl[61] gnd reram_bitcell_7
Xbit_r62_c46 bl[46] br[46] wl[62] gnd reram_bitcell_7
Xbit_r63_c46 bl[46] br[46] wl[63] gnd reram_bitcell_7
Xbit_r0_c47 bl[47] br[47] wl[0] gnd reram_bitcell_7
Xbit_r1_c47 bl[47] br[47] wl[1] gnd reram_bitcell_7
Xbit_r2_c47 bl[47] br[47] wl[2] gnd reram_bitcell_7
Xbit_r3_c47 bl[47] br[47] wl[3] gnd reram_bitcell_7
Xbit_r4_c47 bl[47] br[47] wl[4] gnd reram_bitcell_7
Xbit_r5_c47 bl[47] br[47] wl[5] gnd reram_bitcell_7
Xbit_r6_c47 bl[47] br[47] wl[6] gnd reram_bitcell_7
Xbit_r7_c47 bl[47] br[47] wl[7] gnd reram_bitcell_7
Xbit_r8_c47 bl[47] br[47] wl[8] gnd reram_bitcell_7
Xbit_r9_c47 bl[47] br[47] wl[9] gnd reram_bitcell_7
Xbit_r10_c47 bl[47] br[47] wl[10] gnd reram_bitcell_7
Xbit_r11_c47 bl[47] br[47] wl[11] gnd reram_bitcell_7
Xbit_r12_c47 bl[47] br[47] wl[12] gnd reram_bitcell_7
Xbit_r13_c47 bl[47] br[47] wl[13] gnd reram_bitcell_7
Xbit_r14_c47 bl[47] br[47] wl[14] gnd reram_bitcell_7
Xbit_r15_c47 bl[47] br[47] wl[15] gnd reram_bitcell_7
Xbit_r16_c47 bl[47] br[47] wl[16] gnd reram_bitcell_7
Xbit_r17_c47 bl[47] br[47] wl[17] gnd reram_bitcell_7
Xbit_r18_c47 bl[47] br[47] wl[18] gnd reram_bitcell_7
Xbit_r19_c47 bl[47] br[47] wl[19] gnd reram_bitcell_7
Xbit_r20_c47 bl[47] br[47] wl[20] gnd reram_bitcell_7
Xbit_r21_c47 bl[47] br[47] wl[21] gnd reram_bitcell_7
Xbit_r22_c47 bl[47] br[47] wl[22] gnd reram_bitcell_7
Xbit_r23_c47 bl[47] br[47] wl[23] gnd reram_bitcell_7
Xbit_r24_c47 bl[47] br[47] wl[24] gnd reram_bitcell_7
Xbit_r25_c47 bl[47] br[47] wl[25] gnd reram_bitcell_7
Xbit_r26_c47 bl[47] br[47] wl[26] gnd reram_bitcell_7
Xbit_r27_c47 bl[47] br[47] wl[27] gnd reram_bitcell_7
Xbit_r28_c47 bl[47] br[47] wl[28] gnd reram_bitcell_7
Xbit_r29_c47 bl[47] br[47] wl[29] gnd reram_bitcell_7
Xbit_r30_c47 bl[47] br[47] wl[30] gnd reram_bitcell_7
Xbit_r31_c47 bl[47] br[47] wl[31] gnd reram_bitcell_7
Xbit_r32_c47 bl[47] br[47] wl[32] gnd reram_bitcell_7
Xbit_r33_c47 bl[47] br[47] wl[33] gnd reram_bitcell_7
Xbit_r34_c47 bl[47] br[47] wl[34] gnd reram_bitcell_7
Xbit_r35_c47 bl[47] br[47] wl[35] gnd reram_bitcell_7
Xbit_r36_c47 bl[47] br[47] wl[36] gnd reram_bitcell_7
Xbit_r37_c47 bl[47] br[47] wl[37] gnd reram_bitcell_7
Xbit_r38_c47 bl[47] br[47] wl[38] gnd reram_bitcell_7
Xbit_r39_c47 bl[47] br[47] wl[39] gnd reram_bitcell_7
Xbit_r40_c47 bl[47] br[47] wl[40] gnd reram_bitcell_7
Xbit_r41_c47 bl[47] br[47] wl[41] gnd reram_bitcell_7
Xbit_r42_c47 bl[47] br[47] wl[42] gnd reram_bitcell_7
Xbit_r43_c47 bl[47] br[47] wl[43] gnd reram_bitcell_7
Xbit_r44_c47 bl[47] br[47] wl[44] gnd reram_bitcell_7
Xbit_r45_c47 bl[47] br[47] wl[45] gnd reram_bitcell_7
Xbit_r46_c47 bl[47] br[47] wl[46] gnd reram_bitcell_7
Xbit_r47_c47 bl[47] br[47] wl[47] gnd reram_bitcell_7
Xbit_r48_c47 bl[47] br[47] wl[48] gnd reram_bitcell_7
Xbit_r49_c47 bl[47] br[47] wl[49] gnd reram_bitcell_7
Xbit_r50_c47 bl[47] br[47] wl[50] gnd reram_bitcell_7
Xbit_r51_c47 bl[47] br[47] wl[51] gnd reram_bitcell_7
Xbit_r52_c47 bl[47] br[47] wl[52] gnd reram_bitcell_7
Xbit_r53_c47 bl[47] br[47] wl[53] gnd reram_bitcell_7
Xbit_r54_c47 bl[47] br[47] wl[54] gnd reram_bitcell_7
Xbit_r55_c47 bl[47] br[47] wl[55] gnd reram_bitcell_7
Xbit_r56_c47 bl[47] br[47] wl[56] gnd reram_bitcell_7
Xbit_r57_c47 bl[47] br[47] wl[57] gnd reram_bitcell_7
Xbit_r58_c47 bl[47] br[47] wl[58] gnd reram_bitcell_7
Xbit_r59_c47 bl[47] br[47] wl[59] gnd reram_bitcell_7
Xbit_r60_c47 bl[47] br[47] wl[60] gnd reram_bitcell_7
Xbit_r61_c47 bl[47] br[47] wl[61] gnd reram_bitcell_7
Xbit_r62_c47 bl[47] br[47] wl[62] gnd reram_bitcell_7
Xbit_r63_c47 bl[47] br[47] wl[63] gnd reram_bitcell_7
Xbit_r0_c48 bl[48] br[48] wl[0] gnd reram_bitcell_7
Xbit_r1_c48 bl[48] br[48] wl[1] gnd reram_bitcell_7
Xbit_r2_c48 bl[48] br[48] wl[2] gnd reram_bitcell_7
Xbit_r3_c48 bl[48] br[48] wl[3] gnd reram_bitcell_7
Xbit_r4_c48 bl[48] br[48] wl[4] gnd reram_bitcell_7
Xbit_r5_c48 bl[48] br[48] wl[5] gnd reram_bitcell_7
Xbit_r6_c48 bl[48] br[48] wl[6] gnd reram_bitcell_7
Xbit_r7_c48 bl[48] br[48] wl[7] gnd reram_bitcell_7
Xbit_r8_c48 bl[48] br[48] wl[8] gnd reram_bitcell_7
Xbit_r9_c48 bl[48] br[48] wl[9] gnd reram_bitcell_7
Xbit_r10_c48 bl[48] br[48] wl[10] gnd reram_bitcell_7
Xbit_r11_c48 bl[48] br[48] wl[11] gnd reram_bitcell_7
Xbit_r12_c48 bl[48] br[48] wl[12] gnd reram_bitcell_7
Xbit_r13_c48 bl[48] br[48] wl[13] gnd reram_bitcell_7
Xbit_r14_c48 bl[48] br[48] wl[14] gnd reram_bitcell_7
Xbit_r15_c48 bl[48] br[48] wl[15] gnd reram_bitcell_7
Xbit_r16_c48 bl[48] br[48] wl[16] gnd reram_bitcell_7
Xbit_r17_c48 bl[48] br[48] wl[17] gnd reram_bitcell_7
Xbit_r18_c48 bl[48] br[48] wl[18] gnd reram_bitcell_7
Xbit_r19_c48 bl[48] br[48] wl[19] gnd reram_bitcell_7
Xbit_r20_c48 bl[48] br[48] wl[20] gnd reram_bitcell_7
Xbit_r21_c48 bl[48] br[48] wl[21] gnd reram_bitcell_7
Xbit_r22_c48 bl[48] br[48] wl[22] gnd reram_bitcell_7
Xbit_r23_c48 bl[48] br[48] wl[23] gnd reram_bitcell_7
Xbit_r24_c48 bl[48] br[48] wl[24] gnd reram_bitcell_7
Xbit_r25_c48 bl[48] br[48] wl[25] gnd reram_bitcell_7
Xbit_r26_c48 bl[48] br[48] wl[26] gnd reram_bitcell_7
Xbit_r27_c48 bl[48] br[48] wl[27] gnd reram_bitcell_7
Xbit_r28_c48 bl[48] br[48] wl[28] gnd reram_bitcell_7
Xbit_r29_c48 bl[48] br[48] wl[29] gnd reram_bitcell_7
Xbit_r30_c48 bl[48] br[48] wl[30] gnd reram_bitcell_7
Xbit_r31_c48 bl[48] br[48] wl[31] gnd reram_bitcell_7
Xbit_r32_c48 bl[48] br[48] wl[32] gnd reram_bitcell_7
Xbit_r33_c48 bl[48] br[48] wl[33] gnd reram_bitcell_7
Xbit_r34_c48 bl[48] br[48] wl[34] gnd reram_bitcell_7
Xbit_r35_c48 bl[48] br[48] wl[35] gnd reram_bitcell_7
Xbit_r36_c48 bl[48] br[48] wl[36] gnd reram_bitcell_7
Xbit_r37_c48 bl[48] br[48] wl[37] gnd reram_bitcell_7
Xbit_r38_c48 bl[48] br[48] wl[38] gnd reram_bitcell_7
Xbit_r39_c48 bl[48] br[48] wl[39] gnd reram_bitcell_7
Xbit_r40_c48 bl[48] br[48] wl[40] gnd reram_bitcell_7
Xbit_r41_c48 bl[48] br[48] wl[41] gnd reram_bitcell_7
Xbit_r42_c48 bl[48] br[48] wl[42] gnd reram_bitcell_7
Xbit_r43_c48 bl[48] br[48] wl[43] gnd reram_bitcell_7
Xbit_r44_c48 bl[48] br[48] wl[44] gnd reram_bitcell_7
Xbit_r45_c48 bl[48] br[48] wl[45] gnd reram_bitcell_7
Xbit_r46_c48 bl[48] br[48] wl[46] gnd reram_bitcell_7
Xbit_r47_c48 bl[48] br[48] wl[47] gnd reram_bitcell_7
Xbit_r48_c48 bl[48] br[48] wl[48] gnd reram_bitcell_7
Xbit_r49_c48 bl[48] br[48] wl[49] gnd reram_bitcell_7
Xbit_r50_c48 bl[48] br[48] wl[50] gnd reram_bitcell_7
Xbit_r51_c48 bl[48] br[48] wl[51] gnd reram_bitcell_7
Xbit_r52_c48 bl[48] br[48] wl[52] gnd reram_bitcell_7
Xbit_r53_c48 bl[48] br[48] wl[53] gnd reram_bitcell_7
Xbit_r54_c48 bl[48] br[48] wl[54] gnd reram_bitcell_7
Xbit_r55_c48 bl[48] br[48] wl[55] gnd reram_bitcell_7
Xbit_r56_c48 bl[48] br[48] wl[56] gnd reram_bitcell_7
Xbit_r57_c48 bl[48] br[48] wl[57] gnd reram_bitcell_7
Xbit_r58_c48 bl[48] br[48] wl[58] gnd reram_bitcell_7
Xbit_r59_c48 bl[48] br[48] wl[59] gnd reram_bitcell_7
Xbit_r60_c48 bl[48] br[48] wl[60] gnd reram_bitcell_7
Xbit_r61_c48 bl[48] br[48] wl[61] gnd reram_bitcell_7
Xbit_r62_c48 bl[48] br[48] wl[62] gnd reram_bitcell_7
Xbit_r63_c48 bl[48] br[48] wl[63] gnd reram_bitcell_7
Xbit_r0_c49 bl[49] br[49] wl[0] gnd reram_bitcell_7
Xbit_r1_c49 bl[49] br[49] wl[1] gnd reram_bitcell_7
Xbit_r2_c49 bl[49] br[49] wl[2] gnd reram_bitcell_7
Xbit_r3_c49 bl[49] br[49] wl[3] gnd reram_bitcell_7
Xbit_r4_c49 bl[49] br[49] wl[4] gnd reram_bitcell_7
Xbit_r5_c49 bl[49] br[49] wl[5] gnd reram_bitcell_7
Xbit_r6_c49 bl[49] br[49] wl[6] gnd reram_bitcell_7
Xbit_r7_c49 bl[49] br[49] wl[7] gnd reram_bitcell_7
Xbit_r8_c49 bl[49] br[49] wl[8] gnd reram_bitcell_7
Xbit_r9_c49 bl[49] br[49] wl[9] gnd reram_bitcell_7
Xbit_r10_c49 bl[49] br[49] wl[10] gnd reram_bitcell_7
Xbit_r11_c49 bl[49] br[49] wl[11] gnd reram_bitcell_7
Xbit_r12_c49 bl[49] br[49] wl[12] gnd reram_bitcell_7
Xbit_r13_c49 bl[49] br[49] wl[13] gnd reram_bitcell_7
Xbit_r14_c49 bl[49] br[49] wl[14] gnd reram_bitcell_7
Xbit_r15_c49 bl[49] br[49] wl[15] gnd reram_bitcell_7
Xbit_r16_c49 bl[49] br[49] wl[16] gnd reram_bitcell_7
Xbit_r17_c49 bl[49] br[49] wl[17] gnd reram_bitcell_7
Xbit_r18_c49 bl[49] br[49] wl[18] gnd reram_bitcell_7
Xbit_r19_c49 bl[49] br[49] wl[19] gnd reram_bitcell_7
Xbit_r20_c49 bl[49] br[49] wl[20] gnd reram_bitcell_7
Xbit_r21_c49 bl[49] br[49] wl[21] gnd reram_bitcell_7
Xbit_r22_c49 bl[49] br[49] wl[22] gnd reram_bitcell_7
Xbit_r23_c49 bl[49] br[49] wl[23] gnd reram_bitcell_7
Xbit_r24_c49 bl[49] br[49] wl[24] gnd reram_bitcell_7
Xbit_r25_c49 bl[49] br[49] wl[25] gnd reram_bitcell_7
Xbit_r26_c49 bl[49] br[49] wl[26] gnd reram_bitcell_7
Xbit_r27_c49 bl[49] br[49] wl[27] gnd reram_bitcell_7
Xbit_r28_c49 bl[49] br[49] wl[28] gnd reram_bitcell_7
Xbit_r29_c49 bl[49] br[49] wl[29] gnd reram_bitcell_7
Xbit_r30_c49 bl[49] br[49] wl[30] gnd reram_bitcell_7
Xbit_r31_c49 bl[49] br[49] wl[31] gnd reram_bitcell_7
Xbit_r32_c49 bl[49] br[49] wl[32] gnd reram_bitcell_7
Xbit_r33_c49 bl[49] br[49] wl[33] gnd reram_bitcell_7
Xbit_r34_c49 bl[49] br[49] wl[34] gnd reram_bitcell_7
Xbit_r35_c49 bl[49] br[49] wl[35] gnd reram_bitcell_7
Xbit_r36_c49 bl[49] br[49] wl[36] gnd reram_bitcell_7
Xbit_r37_c49 bl[49] br[49] wl[37] gnd reram_bitcell_7
Xbit_r38_c49 bl[49] br[49] wl[38] gnd reram_bitcell_7
Xbit_r39_c49 bl[49] br[49] wl[39] gnd reram_bitcell_7
Xbit_r40_c49 bl[49] br[49] wl[40] gnd reram_bitcell_7
Xbit_r41_c49 bl[49] br[49] wl[41] gnd reram_bitcell_7
Xbit_r42_c49 bl[49] br[49] wl[42] gnd reram_bitcell_7
Xbit_r43_c49 bl[49] br[49] wl[43] gnd reram_bitcell_7
Xbit_r44_c49 bl[49] br[49] wl[44] gnd reram_bitcell_7
Xbit_r45_c49 bl[49] br[49] wl[45] gnd reram_bitcell_7
Xbit_r46_c49 bl[49] br[49] wl[46] gnd reram_bitcell_7
Xbit_r47_c49 bl[49] br[49] wl[47] gnd reram_bitcell_7
Xbit_r48_c49 bl[49] br[49] wl[48] gnd reram_bitcell_7
Xbit_r49_c49 bl[49] br[49] wl[49] gnd reram_bitcell_7
Xbit_r50_c49 bl[49] br[49] wl[50] gnd reram_bitcell_7
Xbit_r51_c49 bl[49] br[49] wl[51] gnd reram_bitcell_7
Xbit_r52_c49 bl[49] br[49] wl[52] gnd reram_bitcell_7
Xbit_r53_c49 bl[49] br[49] wl[53] gnd reram_bitcell_7
Xbit_r54_c49 bl[49] br[49] wl[54] gnd reram_bitcell_7
Xbit_r55_c49 bl[49] br[49] wl[55] gnd reram_bitcell_7
Xbit_r56_c49 bl[49] br[49] wl[56] gnd reram_bitcell_7
Xbit_r57_c49 bl[49] br[49] wl[57] gnd reram_bitcell_7
Xbit_r58_c49 bl[49] br[49] wl[58] gnd reram_bitcell_7
Xbit_r59_c49 bl[49] br[49] wl[59] gnd reram_bitcell_7
Xbit_r60_c49 bl[49] br[49] wl[60] gnd reram_bitcell_7
Xbit_r61_c49 bl[49] br[49] wl[61] gnd reram_bitcell_7
Xbit_r62_c49 bl[49] br[49] wl[62] gnd reram_bitcell_7
Xbit_r63_c49 bl[49] br[49] wl[63] gnd reram_bitcell_7
Xbit_r0_c50 bl[50] br[50] wl[0] gnd reram_bitcell_7
Xbit_r1_c50 bl[50] br[50] wl[1] gnd reram_bitcell_7
Xbit_r2_c50 bl[50] br[50] wl[2] gnd reram_bitcell_7
Xbit_r3_c50 bl[50] br[50] wl[3] gnd reram_bitcell_7
Xbit_r4_c50 bl[50] br[50] wl[4] gnd reram_bitcell_7
Xbit_r5_c50 bl[50] br[50] wl[5] gnd reram_bitcell_7
Xbit_r6_c50 bl[50] br[50] wl[6] gnd reram_bitcell_7
Xbit_r7_c50 bl[50] br[50] wl[7] gnd reram_bitcell_7
Xbit_r8_c50 bl[50] br[50] wl[8] gnd reram_bitcell_7
Xbit_r9_c50 bl[50] br[50] wl[9] gnd reram_bitcell_7
Xbit_r10_c50 bl[50] br[50] wl[10] gnd reram_bitcell_7
Xbit_r11_c50 bl[50] br[50] wl[11] gnd reram_bitcell_7
Xbit_r12_c50 bl[50] br[50] wl[12] gnd reram_bitcell_7
Xbit_r13_c50 bl[50] br[50] wl[13] gnd reram_bitcell_7
Xbit_r14_c50 bl[50] br[50] wl[14] gnd reram_bitcell_7
Xbit_r15_c50 bl[50] br[50] wl[15] gnd reram_bitcell_7
Xbit_r16_c50 bl[50] br[50] wl[16] gnd reram_bitcell_7
Xbit_r17_c50 bl[50] br[50] wl[17] gnd reram_bitcell_7
Xbit_r18_c50 bl[50] br[50] wl[18] gnd reram_bitcell_7
Xbit_r19_c50 bl[50] br[50] wl[19] gnd reram_bitcell_7
Xbit_r20_c50 bl[50] br[50] wl[20] gnd reram_bitcell_7
Xbit_r21_c50 bl[50] br[50] wl[21] gnd reram_bitcell_7
Xbit_r22_c50 bl[50] br[50] wl[22] gnd reram_bitcell_7
Xbit_r23_c50 bl[50] br[50] wl[23] gnd reram_bitcell_7
Xbit_r24_c50 bl[50] br[50] wl[24] gnd reram_bitcell_7
Xbit_r25_c50 bl[50] br[50] wl[25] gnd reram_bitcell_7
Xbit_r26_c50 bl[50] br[50] wl[26] gnd reram_bitcell_7
Xbit_r27_c50 bl[50] br[50] wl[27] gnd reram_bitcell_7
Xbit_r28_c50 bl[50] br[50] wl[28] gnd reram_bitcell_7
Xbit_r29_c50 bl[50] br[50] wl[29] gnd reram_bitcell_7
Xbit_r30_c50 bl[50] br[50] wl[30] gnd reram_bitcell_7
Xbit_r31_c50 bl[50] br[50] wl[31] gnd reram_bitcell_7
Xbit_r32_c50 bl[50] br[50] wl[32] gnd reram_bitcell_7
Xbit_r33_c50 bl[50] br[50] wl[33] gnd reram_bitcell_7
Xbit_r34_c50 bl[50] br[50] wl[34] gnd reram_bitcell_7
Xbit_r35_c50 bl[50] br[50] wl[35] gnd reram_bitcell_7
Xbit_r36_c50 bl[50] br[50] wl[36] gnd reram_bitcell_7
Xbit_r37_c50 bl[50] br[50] wl[37] gnd reram_bitcell_7
Xbit_r38_c50 bl[50] br[50] wl[38] gnd reram_bitcell_7
Xbit_r39_c50 bl[50] br[50] wl[39] gnd reram_bitcell_7
Xbit_r40_c50 bl[50] br[50] wl[40] gnd reram_bitcell_7
Xbit_r41_c50 bl[50] br[50] wl[41] gnd reram_bitcell_7
Xbit_r42_c50 bl[50] br[50] wl[42] gnd reram_bitcell_7
Xbit_r43_c50 bl[50] br[50] wl[43] gnd reram_bitcell_7
Xbit_r44_c50 bl[50] br[50] wl[44] gnd reram_bitcell_7
Xbit_r45_c50 bl[50] br[50] wl[45] gnd reram_bitcell_7
Xbit_r46_c50 bl[50] br[50] wl[46] gnd reram_bitcell_7
Xbit_r47_c50 bl[50] br[50] wl[47] gnd reram_bitcell_7
Xbit_r48_c50 bl[50] br[50] wl[48] gnd reram_bitcell_7
Xbit_r49_c50 bl[50] br[50] wl[49] gnd reram_bitcell_7
Xbit_r50_c50 bl[50] br[50] wl[50] gnd reram_bitcell_7
Xbit_r51_c50 bl[50] br[50] wl[51] gnd reram_bitcell_7
Xbit_r52_c50 bl[50] br[50] wl[52] gnd reram_bitcell_7
Xbit_r53_c50 bl[50] br[50] wl[53] gnd reram_bitcell_7
Xbit_r54_c50 bl[50] br[50] wl[54] gnd reram_bitcell_7
Xbit_r55_c50 bl[50] br[50] wl[55] gnd reram_bitcell_7
Xbit_r56_c50 bl[50] br[50] wl[56] gnd reram_bitcell_7
Xbit_r57_c50 bl[50] br[50] wl[57] gnd reram_bitcell_7
Xbit_r58_c50 bl[50] br[50] wl[58] gnd reram_bitcell_7
Xbit_r59_c50 bl[50] br[50] wl[59] gnd reram_bitcell_7
Xbit_r60_c50 bl[50] br[50] wl[60] gnd reram_bitcell_7
Xbit_r61_c50 bl[50] br[50] wl[61] gnd reram_bitcell_7
Xbit_r62_c50 bl[50] br[50] wl[62] gnd reram_bitcell_7
Xbit_r63_c50 bl[50] br[50] wl[63] gnd reram_bitcell_7
Xbit_r0_c51 bl[51] br[51] wl[0] gnd reram_bitcell_7
Xbit_r1_c51 bl[51] br[51] wl[1] gnd reram_bitcell_7
Xbit_r2_c51 bl[51] br[51] wl[2] gnd reram_bitcell_7
Xbit_r3_c51 bl[51] br[51] wl[3] gnd reram_bitcell_7
Xbit_r4_c51 bl[51] br[51] wl[4] gnd reram_bitcell_7
Xbit_r5_c51 bl[51] br[51] wl[5] gnd reram_bitcell_7
Xbit_r6_c51 bl[51] br[51] wl[6] gnd reram_bitcell_7
Xbit_r7_c51 bl[51] br[51] wl[7] gnd reram_bitcell_7
Xbit_r8_c51 bl[51] br[51] wl[8] gnd reram_bitcell_7
Xbit_r9_c51 bl[51] br[51] wl[9] gnd reram_bitcell_7
Xbit_r10_c51 bl[51] br[51] wl[10] gnd reram_bitcell_7
Xbit_r11_c51 bl[51] br[51] wl[11] gnd reram_bitcell_7
Xbit_r12_c51 bl[51] br[51] wl[12] gnd reram_bitcell_7
Xbit_r13_c51 bl[51] br[51] wl[13] gnd reram_bitcell_7
Xbit_r14_c51 bl[51] br[51] wl[14] gnd reram_bitcell_7
Xbit_r15_c51 bl[51] br[51] wl[15] gnd reram_bitcell_7
Xbit_r16_c51 bl[51] br[51] wl[16] gnd reram_bitcell_7
Xbit_r17_c51 bl[51] br[51] wl[17] gnd reram_bitcell_7
Xbit_r18_c51 bl[51] br[51] wl[18] gnd reram_bitcell_7
Xbit_r19_c51 bl[51] br[51] wl[19] gnd reram_bitcell_7
Xbit_r20_c51 bl[51] br[51] wl[20] gnd reram_bitcell_7
Xbit_r21_c51 bl[51] br[51] wl[21] gnd reram_bitcell_7
Xbit_r22_c51 bl[51] br[51] wl[22] gnd reram_bitcell_7
Xbit_r23_c51 bl[51] br[51] wl[23] gnd reram_bitcell_7
Xbit_r24_c51 bl[51] br[51] wl[24] gnd reram_bitcell_7
Xbit_r25_c51 bl[51] br[51] wl[25] gnd reram_bitcell_7
Xbit_r26_c51 bl[51] br[51] wl[26] gnd reram_bitcell_7
Xbit_r27_c51 bl[51] br[51] wl[27] gnd reram_bitcell_7
Xbit_r28_c51 bl[51] br[51] wl[28] gnd reram_bitcell_7
Xbit_r29_c51 bl[51] br[51] wl[29] gnd reram_bitcell_7
Xbit_r30_c51 bl[51] br[51] wl[30] gnd reram_bitcell_7
Xbit_r31_c51 bl[51] br[51] wl[31] gnd reram_bitcell_7
Xbit_r32_c51 bl[51] br[51] wl[32] gnd reram_bitcell_7
Xbit_r33_c51 bl[51] br[51] wl[33] gnd reram_bitcell_7
Xbit_r34_c51 bl[51] br[51] wl[34] gnd reram_bitcell_7
Xbit_r35_c51 bl[51] br[51] wl[35] gnd reram_bitcell_7
Xbit_r36_c51 bl[51] br[51] wl[36] gnd reram_bitcell_7
Xbit_r37_c51 bl[51] br[51] wl[37] gnd reram_bitcell_7
Xbit_r38_c51 bl[51] br[51] wl[38] gnd reram_bitcell_7
Xbit_r39_c51 bl[51] br[51] wl[39] gnd reram_bitcell_7
Xbit_r40_c51 bl[51] br[51] wl[40] gnd reram_bitcell_7
Xbit_r41_c51 bl[51] br[51] wl[41] gnd reram_bitcell_7
Xbit_r42_c51 bl[51] br[51] wl[42] gnd reram_bitcell_7
Xbit_r43_c51 bl[51] br[51] wl[43] gnd reram_bitcell_7
Xbit_r44_c51 bl[51] br[51] wl[44] gnd reram_bitcell_7
Xbit_r45_c51 bl[51] br[51] wl[45] gnd reram_bitcell_7
Xbit_r46_c51 bl[51] br[51] wl[46] gnd reram_bitcell_7
Xbit_r47_c51 bl[51] br[51] wl[47] gnd reram_bitcell_7
Xbit_r48_c51 bl[51] br[51] wl[48] gnd reram_bitcell_7
Xbit_r49_c51 bl[51] br[51] wl[49] gnd reram_bitcell_7
Xbit_r50_c51 bl[51] br[51] wl[50] gnd reram_bitcell_7
Xbit_r51_c51 bl[51] br[51] wl[51] gnd reram_bitcell_7
Xbit_r52_c51 bl[51] br[51] wl[52] gnd reram_bitcell_7
Xbit_r53_c51 bl[51] br[51] wl[53] gnd reram_bitcell_7
Xbit_r54_c51 bl[51] br[51] wl[54] gnd reram_bitcell_7
Xbit_r55_c51 bl[51] br[51] wl[55] gnd reram_bitcell_7
Xbit_r56_c51 bl[51] br[51] wl[56] gnd reram_bitcell_7
Xbit_r57_c51 bl[51] br[51] wl[57] gnd reram_bitcell_7
Xbit_r58_c51 bl[51] br[51] wl[58] gnd reram_bitcell_7
Xbit_r59_c51 bl[51] br[51] wl[59] gnd reram_bitcell_7
Xbit_r60_c51 bl[51] br[51] wl[60] gnd reram_bitcell_7
Xbit_r61_c51 bl[51] br[51] wl[61] gnd reram_bitcell_7
Xbit_r62_c51 bl[51] br[51] wl[62] gnd reram_bitcell_7
Xbit_r63_c51 bl[51] br[51] wl[63] gnd reram_bitcell_7
Xbit_r0_c52 bl[52] br[52] wl[0] gnd reram_bitcell_7
Xbit_r1_c52 bl[52] br[52] wl[1] gnd reram_bitcell_7
Xbit_r2_c52 bl[52] br[52] wl[2] gnd reram_bitcell_7
Xbit_r3_c52 bl[52] br[52] wl[3] gnd reram_bitcell_7
Xbit_r4_c52 bl[52] br[52] wl[4] gnd reram_bitcell_7
Xbit_r5_c52 bl[52] br[52] wl[5] gnd reram_bitcell_7
Xbit_r6_c52 bl[52] br[52] wl[6] gnd reram_bitcell_7
Xbit_r7_c52 bl[52] br[52] wl[7] gnd reram_bitcell_7
Xbit_r8_c52 bl[52] br[52] wl[8] gnd reram_bitcell_7
Xbit_r9_c52 bl[52] br[52] wl[9] gnd reram_bitcell_7
Xbit_r10_c52 bl[52] br[52] wl[10] gnd reram_bitcell_7
Xbit_r11_c52 bl[52] br[52] wl[11] gnd reram_bitcell_7
Xbit_r12_c52 bl[52] br[52] wl[12] gnd reram_bitcell_7
Xbit_r13_c52 bl[52] br[52] wl[13] gnd reram_bitcell_7
Xbit_r14_c52 bl[52] br[52] wl[14] gnd reram_bitcell_7
Xbit_r15_c52 bl[52] br[52] wl[15] gnd reram_bitcell_7
Xbit_r16_c52 bl[52] br[52] wl[16] gnd reram_bitcell_7
Xbit_r17_c52 bl[52] br[52] wl[17] gnd reram_bitcell_7
Xbit_r18_c52 bl[52] br[52] wl[18] gnd reram_bitcell_7
Xbit_r19_c52 bl[52] br[52] wl[19] gnd reram_bitcell_7
Xbit_r20_c52 bl[52] br[52] wl[20] gnd reram_bitcell_7
Xbit_r21_c52 bl[52] br[52] wl[21] gnd reram_bitcell_7
Xbit_r22_c52 bl[52] br[52] wl[22] gnd reram_bitcell_7
Xbit_r23_c52 bl[52] br[52] wl[23] gnd reram_bitcell_7
Xbit_r24_c52 bl[52] br[52] wl[24] gnd reram_bitcell_7
Xbit_r25_c52 bl[52] br[52] wl[25] gnd reram_bitcell_7
Xbit_r26_c52 bl[52] br[52] wl[26] gnd reram_bitcell_7
Xbit_r27_c52 bl[52] br[52] wl[27] gnd reram_bitcell_7
Xbit_r28_c52 bl[52] br[52] wl[28] gnd reram_bitcell_7
Xbit_r29_c52 bl[52] br[52] wl[29] gnd reram_bitcell_7
Xbit_r30_c52 bl[52] br[52] wl[30] gnd reram_bitcell_7
Xbit_r31_c52 bl[52] br[52] wl[31] gnd reram_bitcell_7
Xbit_r32_c52 bl[52] br[52] wl[32] gnd reram_bitcell_7
Xbit_r33_c52 bl[52] br[52] wl[33] gnd reram_bitcell_7
Xbit_r34_c52 bl[52] br[52] wl[34] gnd reram_bitcell_7
Xbit_r35_c52 bl[52] br[52] wl[35] gnd reram_bitcell_7
Xbit_r36_c52 bl[52] br[52] wl[36] gnd reram_bitcell_7
Xbit_r37_c52 bl[52] br[52] wl[37] gnd reram_bitcell_7
Xbit_r38_c52 bl[52] br[52] wl[38] gnd reram_bitcell_7
Xbit_r39_c52 bl[52] br[52] wl[39] gnd reram_bitcell_7
Xbit_r40_c52 bl[52] br[52] wl[40] gnd reram_bitcell_7
Xbit_r41_c52 bl[52] br[52] wl[41] gnd reram_bitcell_7
Xbit_r42_c52 bl[52] br[52] wl[42] gnd reram_bitcell_7
Xbit_r43_c52 bl[52] br[52] wl[43] gnd reram_bitcell_7
Xbit_r44_c52 bl[52] br[52] wl[44] gnd reram_bitcell_7
Xbit_r45_c52 bl[52] br[52] wl[45] gnd reram_bitcell_7
Xbit_r46_c52 bl[52] br[52] wl[46] gnd reram_bitcell_7
Xbit_r47_c52 bl[52] br[52] wl[47] gnd reram_bitcell_7
Xbit_r48_c52 bl[52] br[52] wl[48] gnd reram_bitcell_7
Xbit_r49_c52 bl[52] br[52] wl[49] gnd reram_bitcell_7
Xbit_r50_c52 bl[52] br[52] wl[50] gnd reram_bitcell_7
Xbit_r51_c52 bl[52] br[52] wl[51] gnd reram_bitcell_7
Xbit_r52_c52 bl[52] br[52] wl[52] gnd reram_bitcell_7
Xbit_r53_c52 bl[52] br[52] wl[53] gnd reram_bitcell_7
Xbit_r54_c52 bl[52] br[52] wl[54] gnd reram_bitcell_7
Xbit_r55_c52 bl[52] br[52] wl[55] gnd reram_bitcell_7
Xbit_r56_c52 bl[52] br[52] wl[56] gnd reram_bitcell_7
Xbit_r57_c52 bl[52] br[52] wl[57] gnd reram_bitcell_7
Xbit_r58_c52 bl[52] br[52] wl[58] gnd reram_bitcell_7
Xbit_r59_c52 bl[52] br[52] wl[59] gnd reram_bitcell_7
Xbit_r60_c52 bl[52] br[52] wl[60] gnd reram_bitcell_7
Xbit_r61_c52 bl[52] br[52] wl[61] gnd reram_bitcell_7
Xbit_r62_c52 bl[52] br[52] wl[62] gnd reram_bitcell_7
Xbit_r63_c52 bl[52] br[52] wl[63] gnd reram_bitcell_7
Xbit_r0_c53 bl[53] br[53] wl[0] gnd reram_bitcell_7
Xbit_r1_c53 bl[53] br[53] wl[1] gnd reram_bitcell_7
Xbit_r2_c53 bl[53] br[53] wl[2] gnd reram_bitcell_7
Xbit_r3_c53 bl[53] br[53] wl[3] gnd reram_bitcell_7
Xbit_r4_c53 bl[53] br[53] wl[4] gnd reram_bitcell_7
Xbit_r5_c53 bl[53] br[53] wl[5] gnd reram_bitcell_7
Xbit_r6_c53 bl[53] br[53] wl[6] gnd reram_bitcell_7
Xbit_r7_c53 bl[53] br[53] wl[7] gnd reram_bitcell_7
Xbit_r8_c53 bl[53] br[53] wl[8] gnd reram_bitcell_7
Xbit_r9_c53 bl[53] br[53] wl[9] gnd reram_bitcell_7
Xbit_r10_c53 bl[53] br[53] wl[10] gnd reram_bitcell_7
Xbit_r11_c53 bl[53] br[53] wl[11] gnd reram_bitcell_7
Xbit_r12_c53 bl[53] br[53] wl[12] gnd reram_bitcell_7
Xbit_r13_c53 bl[53] br[53] wl[13] gnd reram_bitcell_7
Xbit_r14_c53 bl[53] br[53] wl[14] gnd reram_bitcell_7
Xbit_r15_c53 bl[53] br[53] wl[15] gnd reram_bitcell_7
Xbit_r16_c53 bl[53] br[53] wl[16] gnd reram_bitcell_7
Xbit_r17_c53 bl[53] br[53] wl[17] gnd reram_bitcell_7
Xbit_r18_c53 bl[53] br[53] wl[18] gnd reram_bitcell_7
Xbit_r19_c53 bl[53] br[53] wl[19] gnd reram_bitcell_7
Xbit_r20_c53 bl[53] br[53] wl[20] gnd reram_bitcell_7
Xbit_r21_c53 bl[53] br[53] wl[21] gnd reram_bitcell_7
Xbit_r22_c53 bl[53] br[53] wl[22] gnd reram_bitcell_7
Xbit_r23_c53 bl[53] br[53] wl[23] gnd reram_bitcell_7
Xbit_r24_c53 bl[53] br[53] wl[24] gnd reram_bitcell_7
Xbit_r25_c53 bl[53] br[53] wl[25] gnd reram_bitcell_7
Xbit_r26_c53 bl[53] br[53] wl[26] gnd reram_bitcell_7
Xbit_r27_c53 bl[53] br[53] wl[27] gnd reram_bitcell_7
Xbit_r28_c53 bl[53] br[53] wl[28] gnd reram_bitcell_7
Xbit_r29_c53 bl[53] br[53] wl[29] gnd reram_bitcell_7
Xbit_r30_c53 bl[53] br[53] wl[30] gnd reram_bitcell_7
Xbit_r31_c53 bl[53] br[53] wl[31] gnd reram_bitcell_7
Xbit_r32_c53 bl[53] br[53] wl[32] gnd reram_bitcell_7
Xbit_r33_c53 bl[53] br[53] wl[33] gnd reram_bitcell_7
Xbit_r34_c53 bl[53] br[53] wl[34] gnd reram_bitcell_7
Xbit_r35_c53 bl[53] br[53] wl[35] gnd reram_bitcell_7
Xbit_r36_c53 bl[53] br[53] wl[36] gnd reram_bitcell_7
Xbit_r37_c53 bl[53] br[53] wl[37] gnd reram_bitcell_7
Xbit_r38_c53 bl[53] br[53] wl[38] gnd reram_bitcell_7
Xbit_r39_c53 bl[53] br[53] wl[39] gnd reram_bitcell_7
Xbit_r40_c53 bl[53] br[53] wl[40] gnd reram_bitcell_7
Xbit_r41_c53 bl[53] br[53] wl[41] gnd reram_bitcell_7
Xbit_r42_c53 bl[53] br[53] wl[42] gnd reram_bitcell_7
Xbit_r43_c53 bl[53] br[53] wl[43] gnd reram_bitcell_7
Xbit_r44_c53 bl[53] br[53] wl[44] gnd reram_bitcell_7
Xbit_r45_c53 bl[53] br[53] wl[45] gnd reram_bitcell_7
Xbit_r46_c53 bl[53] br[53] wl[46] gnd reram_bitcell_7
Xbit_r47_c53 bl[53] br[53] wl[47] gnd reram_bitcell_7
Xbit_r48_c53 bl[53] br[53] wl[48] gnd reram_bitcell_7
Xbit_r49_c53 bl[53] br[53] wl[49] gnd reram_bitcell_7
Xbit_r50_c53 bl[53] br[53] wl[50] gnd reram_bitcell_7
Xbit_r51_c53 bl[53] br[53] wl[51] gnd reram_bitcell_7
Xbit_r52_c53 bl[53] br[53] wl[52] gnd reram_bitcell_7
Xbit_r53_c53 bl[53] br[53] wl[53] gnd reram_bitcell_7
Xbit_r54_c53 bl[53] br[53] wl[54] gnd reram_bitcell_7
Xbit_r55_c53 bl[53] br[53] wl[55] gnd reram_bitcell_7
Xbit_r56_c53 bl[53] br[53] wl[56] gnd reram_bitcell_7
Xbit_r57_c53 bl[53] br[53] wl[57] gnd reram_bitcell_7
Xbit_r58_c53 bl[53] br[53] wl[58] gnd reram_bitcell_7
Xbit_r59_c53 bl[53] br[53] wl[59] gnd reram_bitcell_7
Xbit_r60_c53 bl[53] br[53] wl[60] gnd reram_bitcell_7
Xbit_r61_c53 bl[53] br[53] wl[61] gnd reram_bitcell_7
Xbit_r62_c53 bl[53] br[53] wl[62] gnd reram_bitcell_7
Xbit_r63_c53 bl[53] br[53] wl[63] gnd reram_bitcell_7
Xbit_r0_c54 bl[54] br[54] wl[0] gnd reram_bitcell_7
Xbit_r1_c54 bl[54] br[54] wl[1] gnd reram_bitcell_7
Xbit_r2_c54 bl[54] br[54] wl[2] gnd reram_bitcell_7
Xbit_r3_c54 bl[54] br[54] wl[3] gnd reram_bitcell_7
Xbit_r4_c54 bl[54] br[54] wl[4] gnd reram_bitcell_7
Xbit_r5_c54 bl[54] br[54] wl[5] gnd reram_bitcell_7
Xbit_r6_c54 bl[54] br[54] wl[6] gnd reram_bitcell_7
Xbit_r7_c54 bl[54] br[54] wl[7] gnd reram_bitcell_7
Xbit_r8_c54 bl[54] br[54] wl[8] gnd reram_bitcell_7
Xbit_r9_c54 bl[54] br[54] wl[9] gnd reram_bitcell_7
Xbit_r10_c54 bl[54] br[54] wl[10] gnd reram_bitcell_7
Xbit_r11_c54 bl[54] br[54] wl[11] gnd reram_bitcell_7
Xbit_r12_c54 bl[54] br[54] wl[12] gnd reram_bitcell_7
Xbit_r13_c54 bl[54] br[54] wl[13] gnd reram_bitcell_7
Xbit_r14_c54 bl[54] br[54] wl[14] gnd reram_bitcell_7
Xbit_r15_c54 bl[54] br[54] wl[15] gnd reram_bitcell_7
Xbit_r16_c54 bl[54] br[54] wl[16] gnd reram_bitcell_7
Xbit_r17_c54 bl[54] br[54] wl[17] gnd reram_bitcell_7
Xbit_r18_c54 bl[54] br[54] wl[18] gnd reram_bitcell_7
Xbit_r19_c54 bl[54] br[54] wl[19] gnd reram_bitcell_7
Xbit_r20_c54 bl[54] br[54] wl[20] gnd reram_bitcell_7
Xbit_r21_c54 bl[54] br[54] wl[21] gnd reram_bitcell_7
Xbit_r22_c54 bl[54] br[54] wl[22] gnd reram_bitcell_7
Xbit_r23_c54 bl[54] br[54] wl[23] gnd reram_bitcell_7
Xbit_r24_c54 bl[54] br[54] wl[24] gnd reram_bitcell_7
Xbit_r25_c54 bl[54] br[54] wl[25] gnd reram_bitcell_7
Xbit_r26_c54 bl[54] br[54] wl[26] gnd reram_bitcell_7
Xbit_r27_c54 bl[54] br[54] wl[27] gnd reram_bitcell_7
Xbit_r28_c54 bl[54] br[54] wl[28] gnd reram_bitcell_7
Xbit_r29_c54 bl[54] br[54] wl[29] gnd reram_bitcell_7
Xbit_r30_c54 bl[54] br[54] wl[30] gnd reram_bitcell_7
Xbit_r31_c54 bl[54] br[54] wl[31] gnd reram_bitcell_7
Xbit_r32_c54 bl[54] br[54] wl[32] gnd reram_bitcell_7
Xbit_r33_c54 bl[54] br[54] wl[33] gnd reram_bitcell_7
Xbit_r34_c54 bl[54] br[54] wl[34] gnd reram_bitcell_7
Xbit_r35_c54 bl[54] br[54] wl[35] gnd reram_bitcell_7
Xbit_r36_c54 bl[54] br[54] wl[36] gnd reram_bitcell_7
Xbit_r37_c54 bl[54] br[54] wl[37] gnd reram_bitcell_7
Xbit_r38_c54 bl[54] br[54] wl[38] gnd reram_bitcell_7
Xbit_r39_c54 bl[54] br[54] wl[39] gnd reram_bitcell_7
Xbit_r40_c54 bl[54] br[54] wl[40] gnd reram_bitcell_7
Xbit_r41_c54 bl[54] br[54] wl[41] gnd reram_bitcell_7
Xbit_r42_c54 bl[54] br[54] wl[42] gnd reram_bitcell_7
Xbit_r43_c54 bl[54] br[54] wl[43] gnd reram_bitcell_7
Xbit_r44_c54 bl[54] br[54] wl[44] gnd reram_bitcell_7
Xbit_r45_c54 bl[54] br[54] wl[45] gnd reram_bitcell_7
Xbit_r46_c54 bl[54] br[54] wl[46] gnd reram_bitcell_7
Xbit_r47_c54 bl[54] br[54] wl[47] gnd reram_bitcell_7
Xbit_r48_c54 bl[54] br[54] wl[48] gnd reram_bitcell_7
Xbit_r49_c54 bl[54] br[54] wl[49] gnd reram_bitcell_7
Xbit_r50_c54 bl[54] br[54] wl[50] gnd reram_bitcell_7
Xbit_r51_c54 bl[54] br[54] wl[51] gnd reram_bitcell_7
Xbit_r52_c54 bl[54] br[54] wl[52] gnd reram_bitcell_7
Xbit_r53_c54 bl[54] br[54] wl[53] gnd reram_bitcell_7
Xbit_r54_c54 bl[54] br[54] wl[54] gnd reram_bitcell_7
Xbit_r55_c54 bl[54] br[54] wl[55] gnd reram_bitcell_7
Xbit_r56_c54 bl[54] br[54] wl[56] gnd reram_bitcell_7
Xbit_r57_c54 bl[54] br[54] wl[57] gnd reram_bitcell_7
Xbit_r58_c54 bl[54] br[54] wl[58] gnd reram_bitcell_7
Xbit_r59_c54 bl[54] br[54] wl[59] gnd reram_bitcell_7
Xbit_r60_c54 bl[54] br[54] wl[60] gnd reram_bitcell_7
Xbit_r61_c54 bl[54] br[54] wl[61] gnd reram_bitcell_7
Xbit_r62_c54 bl[54] br[54] wl[62] gnd reram_bitcell_7
Xbit_r63_c54 bl[54] br[54] wl[63] gnd reram_bitcell_7
Xbit_r0_c55 bl[55] br[55] wl[0] gnd reram_bitcell_7
Xbit_r1_c55 bl[55] br[55] wl[1] gnd reram_bitcell_7
Xbit_r2_c55 bl[55] br[55] wl[2] gnd reram_bitcell_7
Xbit_r3_c55 bl[55] br[55] wl[3] gnd reram_bitcell_7
Xbit_r4_c55 bl[55] br[55] wl[4] gnd reram_bitcell_7
Xbit_r5_c55 bl[55] br[55] wl[5] gnd reram_bitcell_7
Xbit_r6_c55 bl[55] br[55] wl[6] gnd reram_bitcell_7
Xbit_r7_c55 bl[55] br[55] wl[7] gnd reram_bitcell_7
Xbit_r8_c55 bl[55] br[55] wl[8] gnd reram_bitcell_7
Xbit_r9_c55 bl[55] br[55] wl[9] gnd reram_bitcell_7
Xbit_r10_c55 bl[55] br[55] wl[10] gnd reram_bitcell_7
Xbit_r11_c55 bl[55] br[55] wl[11] gnd reram_bitcell_7
Xbit_r12_c55 bl[55] br[55] wl[12] gnd reram_bitcell_7
Xbit_r13_c55 bl[55] br[55] wl[13] gnd reram_bitcell_7
Xbit_r14_c55 bl[55] br[55] wl[14] gnd reram_bitcell_7
Xbit_r15_c55 bl[55] br[55] wl[15] gnd reram_bitcell_7
Xbit_r16_c55 bl[55] br[55] wl[16] gnd reram_bitcell_7
Xbit_r17_c55 bl[55] br[55] wl[17] gnd reram_bitcell_7
Xbit_r18_c55 bl[55] br[55] wl[18] gnd reram_bitcell_7
Xbit_r19_c55 bl[55] br[55] wl[19] gnd reram_bitcell_7
Xbit_r20_c55 bl[55] br[55] wl[20] gnd reram_bitcell_7
Xbit_r21_c55 bl[55] br[55] wl[21] gnd reram_bitcell_7
Xbit_r22_c55 bl[55] br[55] wl[22] gnd reram_bitcell_7
Xbit_r23_c55 bl[55] br[55] wl[23] gnd reram_bitcell_7
Xbit_r24_c55 bl[55] br[55] wl[24] gnd reram_bitcell_7
Xbit_r25_c55 bl[55] br[55] wl[25] gnd reram_bitcell_7
Xbit_r26_c55 bl[55] br[55] wl[26] gnd reram_bitcell_7
Xbit_r27_c55 bl[55] br[55] wl[27] gnd reram_bitcell_7
Xbit_r28_c55 bl[55] br[55] wl[28] gnd reram_bitcell_7
Xbit_r29_c55 bl[55] br[55] wl[29] gnd reram_bitcell_7
Xbit_r30_c55 bl[55] br[55] wl[30] gnd reram_bitcell_7
Xbit_r31_c55 bl[55] br[55] wl[31] gnd reram_bitcell_7
Xbit_r32_c55 bl[55] br[55] wl[32] gnd reram_bitcell_7
Xbit_r33_c55 bl[55] br[55] wl[33] gnd reram_bitcell_7
Xbit_r34_c55 bl[55] br[55] wl[34] gnd reram_bitcell_7
Xbit_r35_c55 bl[55] br[55] wl[35] gnd reram_bitcell_7
Xbit_r36_c55 bl[55] br[55] wl[36] gnd reram_bitcell_7
Xbit_r37_c55 bl[55] br[55] wl[37] gnd reram_bitcell_7
Xbit_r38_c55 bl[55] br[55] wl[38] gnd reram_bitcell_7
Xbit_r39_c55 bl[55] br[55] wl[39] gnd reram_bitcell_7
Xbit_r40_c55 bl[55] br[55] wl[40] gnd reram_bitcell_7
Xbit_r41_c55 bl[55] br[55] wl[41] gnd reram_bitcell_7
Xbit_r42_c55 bl[55] br[55] wl[42] gnd reram_bitcell_7
Xbit_r43_c55 bl[55] br[55] wl[43] gnd reram_bitcell_7
Xbit_r44_c55 bl[55] br[55] wl[44] gnd reram_bitcell_7
Xbit_r45_c55 bl[55] br[55] wl[45] gnd reram_bitcell_7
Xbit_r46_c55 bl[55] br[55] wl[46] gnd reram_bitcell_7
Xbit_r47_c55 bl[55] br[55] wl[47] gnd reram_bitcell_7
Xbit_r48_c55 bl[55] br[55] wl[48] gnd reram_bitcell_7
Xbit_r49_c55 bl[55] br[55] wl[49] gnd reram_bitcell_7
Xbit_r50_c55 bl[55] br[55] wl[50] gnd reram_bitcell_7
Xbit_r51_c55 bl[55] br[55] wl[51] gnd reram_bitcell_7
Xbit_r52_c55 bl[55] br[55] wl[52] gnd reram_bitcell_7
Xbit_r53_c55 bl[55] br[55] wl[53] gnd reram_bitcell_7
Xbit_r54_c55 bl[55] br[55] wl[54] gnd reram_bitcell_7
Xbit_r55_c55 bl[55] br[55] wl[55] gnd reram_bitcell_7
Xbit_r56_c55 bl[55] br[55] wl[56] gnd reram_bitcell_7
Xbit_r57_c55 bl[55] br[55] wl[57] gnd reram_bitcell_7
Xbit_r58_c55 bl[55] br[55] wl[58] gnd reram_bitcell_7
Xbit_r59_c55 bl[55] br[55] wl[59] gnd reram_bitcell_7
Xbit_r60_c55 bl[55] br[55] wl[60] gnd reram_bitcell_7
Xbit_r61_c55 bl[55] br[55] wl[61] gnd reram_bitcell_7
Xbit_r62_c55 bl[55] br[55] wl[62] gnd reram_bitcell_7
Xbit_r63_c55 bl[55] br[55] wl[63] gnd reram_bitcell_7
Xbit_r0_c56 bl[56] br[56] wl[0] gnd reram_bitcell_7
Xbit_r1_c56 bl[56] br[56] wl[1] gnd reram_bitcell_7
Xbit_r2_c56 bl[56] br[56] wl[2] gnd reram_bitcell_7
Xbit_r3_c56 bl[56] br[56] wl[3] gnd reram_bitcell_7
Xbit_r4_c56 bl[56] br[56] wl[4] gnd reram_bitcell_7
Xbit_r5_c56 bl[56] br[56] wl[5] gnd reram_bitcell_7
Xbit_r6_c56 bl[56] br[56] wl[6] gnd reram_bitcell_7
Xbit_r7_c56 bl[56] br[56] wl[7] gnd reram_bitcell_7
Xbit_r8_c56 bl[56] br[56] wl[8] gnd reram_bitcell_7
Xbit_r9_c56 bl[56] br[56] wl[9] gnd reram_bitcell_7
Xbit_r10_c56 bl[56] br[56] wl[10] gnd reram_bitcell_7
Xbit_r11_c56 bl[56] br[56] wl[11] gnd reram_bitcell_7
Xbit_r12_c56 bl[56] br[56] wl[12] gnd reram_bitcell_7
Xbit_r13_c56 bl[56] br[56] wl[13] gnd reram_bitcell_7
Xbit_r14_c56 bl[56] br[56] wl[14] gnd reram_bitcell_7
Xbit_r15_c56 bl[56] br[56] wl[15] gnd reram_bitcell_7
Xbit_r16_c56 bl[56] br[56] wl[16] gnd reram_bitcell_7
Xbit_r17_c56 bl[56] br[56] wl[17] gnd reram_bitcell_7
Xbit_r18_c56 bl[56] br[56] wl[18] gnd reram_bitcell_7
Xbit_r19_c56 bl[56] br[56] wl[19] gnd reram_bitcell_7
Xbit_r20_c56 bl[56] br[56] wl[20] gnd reram_bitcell_7
Xbit_r21_c56 bl[56] br[56] wl[21] gnd reram_bitcell_7
Xbit_r22_c56 bl[56] br[56] wl[22] gnd reram_bitcell_7
Xbit_r23_c56 bl[56] br[56] wl[23] gnd reram_bitcell_7
Xbit_r24_c56 bl[56] br[56] wl[24] gnd reram_bitcell_7
Xbit_r25_c56 bl[56] br[56] wl[25] gnd reram_bitcell_7
Xbit_r26_c56 bl[56] br[56] wl[26] gnd reram_bitcell_7
Xbit_r27_c56 bl[56] br[56] wl[27] gnd reram_bitcell_7
Xbit_r28_c56 bl[56] br[56] wl[28] gnd reram_bitcell_7
Xbit_r29_c56 bl[56] br[56] wl[29] gnd reram_bitcell_7
Xbit_r30_c56 bl[56] br[56] wl[30] gnd reram_bitcell_7
Xbit_r31_c56 bl[56] br[56] wl[31] gnd reram_bitcell_7
Xbit_r32_c56 bl[56] br[56] wl[32] gnd reram_bitcell_7
Xbit_r33_c56 bl[56] br[56] wl[33] gnd reram_bitcell_7
Xbit_r34_c56 bl[56] br[56] wl[34] gnd reram_bitcell_7
Xbit_r35_c56 bl[56] br[56] wl[35] gnd reram_bitcell_7
Xbit_r36_c56 bl[56] br[56] wl[36] gnd reram_bitcell_7
Xbit_r37_c56 bl[56] br[56] wl[37] gnd reram_bitcell_7
Xbit_r38_c56 bl[56] br[56] wl[38] gnd reram_bitcell_7
Xbit_r39_c56 bl[56] br[56] wl[39] gnd reram_bitcell_7
Xbit_r40_c56 bl[56] br[56] wl[40] gnd reram_bitcell_7
Xbit_r41_c56 bl[56] br[56] wl[41] gnd reram_bitcell_7
Xbit_r42_c56 bl[56] br[56] wl[42] gnd reram_bitcell_7
Xbit_r43_c56 bl[56] br[56] wl[43] gnd reram_bitcell_7
Xbit_r44_c56 bl[56] br[56] wl[44] gnd reram_bitcell_7
Xbit_r45_c56 bl[56] br[56] wl[45] gnd reram_bitcell_7
Xbit_r46_c56 bl[56] br[56] wl[46] gnd reram_bitcell_7
Xbit_r47_c56 bl[56] br[56] wl[47] gnd reram_bitcell_7
Xbit_r48_c56 bl[56] br[56] wl[48] gnd reram_bitcell_7
Xbit_r49_c56 bl[56] br[56] wl[49] gnd reram_bitcell_7
Xbit_r50_c56 bl[56] br[56] wl[50] gnd reram_bitcell_7
Xbit_r51_c56 bl[56] br[56] wl[51] gnd reram_bitcell_7
Xbit_r52_c56 bl[56] br[56] wl[52] gnd reram_bitcell_7
Xbit_r53_c56 bl[56] br[56] wl[53] gnd reram_bitcell_7
Xbit_r54_c56 bl[56] br[56] wl[54] gnd reram_bitcell_7
Xbit_r55_c56 bl[56] br[56] wl[55] gnd reram_bitcell_7
Xbit_r56_c56 bl[56] br[56] wl[56] gnd reram_bitcell_7
Xbit_r57_c56 bl[56] br[56] wl[57] gnd reram_bitcell_7
Xbit_r58_c56 bl[56] br[56] wl[58] gnd reram_bitcell_7
Xbit_r59_c56 bl[56] br[56] wl[59] gnd reram_bitcell_7
Xbit_r60_c56 bl[56] br[56] wl[60] gnd reram_bitcell_7
Xbit_r61_c56 bl[56] br[56] wl[61] gnd reram_bitcell_7
Xbit_r62_c56 bl[56] br[56] wl[62] gnd reram_bitcell_7
Xbit_r63_c56 bl[56] br[56] wl[63] gnd reram_bitcell_7
Xbit_r0_c57 bl[57] br[57] wl[0] gnd reram_bitcell_7
Xbit_r1_c57 bl[57] br[57] wl[1] gnd reram_bitcell_7
Xbit_r2_c57 bl[57] br[57] wl[2] gnd reram_bitcell_7
Xbit_r3_c57 bl[57] br[57] wl[3] gnd reram_bitcell_7
Xbit_r4_c57 bl[57] br[57] wl[4] gnd reram_bitcell_7
Xbit_r5_c57 bl[57] br[57] wl[5] gnd reram_bitcell_7
Xbit_r6_c57 bl[57] br[57] wl[6] gnd reram_bitcell_7
Xbit_r7_c57 bl[57] br[57] wl[7] gnd reram_bitcell_7
Xbit_r8_c57 bl[57] br[57] wl[8] gnd reram_bitcell_7
Xbit_r9_c57 bl[57] br[57] wl[9] gnd reram_bitcell_7
Xbit_r10_c57 bl[57] br[57] wl[10] gnd reram_bitcell_7
Xbit_r11_c57 bl[57] br[57] wl[11] gnd reram_bitcell_7
Xbit_r12_c57 bl[57] br[57] wl[12] gnd reram_bitcell_7
Xbit_r13_c57 bl[57] br[57] wl[13] gnd reram_bitcell_7
Xbit_r14_c57 bl[57] br[57] wl[14] gnd reram_bitcell_7
Xbit_r15_c57 bl[57] br[57] wl[15] gnd reram_bitcell_7
Xbit_r16_c57 bl[57] br[57] wl[16] gnd reram_bitcell_7
Xbit_r17_c57 bl[57] br[57] wl[17] gnd reram_bitcell_7
Xbit_r18_c57 bl[57] br[57] wl[18] gnd reram_bitcell_7
Xbit_r19_c57 bl[57] br[57] wl[19] gnd reram_bitcell_7
Xbit_r20_c57 bl[57] br[57] wl[20] gnd reram_bitcell_7
Xbit_r21_c57 bl[57] br[57] wl[21] gnd reram_bitcell_7
Xbit_r22_c57 bl[57] br[57] wl[22] gnd reram_bitcell_7
Xbit_r23_c57 bl[57] br[57] wl[23] gnd reram_bitcell_7
Xbit_r24_c57 bl[57] br[57] wl[24] gnd reram_bitcell_7
Xbit_r25_c57 bl[57] br[57] wl[25] gnd reram_bitcell_7
Xbit_r26_c57 bl[57] br[57] wl[26] gnd reram_bitcell_7
Xbit_r27_c57 bl[57] br[57] wl[27] gnd reram_bitcell_7
Xbit_r28_c57 bl[57] br[57] wl[28] gnd reram_bitcell_7
Xbit_r29_c57 bl[57] br[57] wl[29] gnd reram_bitcell_7
Xbit_r30_c57 bl[57] br[57] wl[30] gnd reram_bitcell_7
Xbit_r31_c57 bl[57] br[57] wl[31] gnd reram_bitcell_7
Xbit_r32_c57 bl[57] br[57] wl[32] gnd reram_bitcell_7
Xbit_r33_c57 bl[57] br[57] wl[33] gnd reram_bitcell_7
Xbit_r34_c57 bl[57] br[57] wl[34] gnd reram_bitcell_7
Xbit_r35_c57 bl[57] br[57] wl[35] gnd reram_bitcell_7
Xbit_r36_c57 bl[57] br[57] wl[36] gnd reram_bitcell_7
Xbit_r37_c57 bl[57] br[57] wl[37] gnd reram_bitcell_7
Xbit_r38_c57 bl[57] br[57] wl[38] gnd reram_bitcell_7
Xbit_r39_c57 bl[57] br[57] wl[39] gnd reram_bitcell_7
Xbit_r40_c57 bl[57] br[57] wl[40] gnd reram_bitcell_7
Xbit_r41_c57 bl[57] br[57] wl[41] gnd reram_bitcell_7
Xbit_r42_c57 bl[57] br[57] wl[42] gnd reram_bitcell_7
Xbit_r43_c57 bl[57] br[57] wl[43] gnd reram_bitcell_7
Xbit_r44_c57 bl[57] br[57] wl[44] gnd reram_bitcell_7
Xbit_r45_c57 bl[57] br[57] wl[45] gnd reram_bitcell_7
Xbit_r46_c57 bl[57] br[57] wl[46] gnd reram_bitcell_7
Xbit_r47_c57 bl[57] br[57] wl[47] gnd reram_bitcell_7
Xbit_r48_c57 bl[57] br[57] wl[48] gnd reram_bitcell_7
Xbit_r49_c57 bl[57] br[57] wl[49] gnd reram_bitcell_7
Xbit_r50_c57 bl[57] br[57] wl[50] gnd reram_bitcell_7
Xbit_r51_c57 bl[57] br[57] wl[51] gnd reram_bitcell_7
Xbit_r52_c57 bl[57] br[57] wl[52] gnd reram_bitcell_7
Xbit_r53_c57 bl[57] br[57] wl[53] gnd reram_bitcell_7
Xbit_r54_c57 bl[57] br[57] wl[54] gnd reram_bitcell_7
Xbit_r55_c57 bl[57] br[57] wl[55] gnd reram_bitcell_7
Xbit_r56_c57 bl[57] br[57] wl[56] gnd reram_bitcell_7
Xbit_r57_c57 bl[57] br[57] wl[57] gnd reram_bitcell_7
Xbit_r58_c57 bl[57] br[57] wl[58] gnd reram_bitcell_7
Xbit_r59_c57 bl[57] br[57] wl[59] gnd reram_bitcell_7
Xbit_r60_c57 bl[57] br[57] wl[60] gnd reram_bitcell_7
Xbit_r61_c57 bl[57] br[57] wl[61] gnd reram_bitcell_7
Xbit_r62_c57 bl[57] br[57] wl[62] gnd reram_bitcell_7
Xbit_r63_c57 bl[57] br[57] wl[63] gnd reram_bitcell_7
Xbit_r0_c58 bl[58] br[58] wl[0] gnd reram_bitcell_7
Xbit_r1_c58 bl[58] br[58] wl[1] gnd reram_bitcell_7
Xbit_r2_c58 bl[58] br[58] wl[2] gnd reram_bitcell_7
Xbit_r3_c58 bl[58] br[58] wl[3] gnd reram_bitcell_7
Xbit_r4_c58 bl[58] br[58] wl[4] gnd reram_bitcell_7
Xbit_r5_c58 bl[58] br[58] wl[5] gnd reram_bitcell_7
Xbit_r6_c58 bl[58] br[58] wl[6] gnd reram_bitcell_7
Xbit_r7_c58 bl[58] br[58] wl[7] gnd reram_bitcell_7
Xbit_r8_c58 bl[58] br[58] wl[8] gnd reram_bitcell_7
Xbit_r9_c58 bl[58] br[58] wl[9] gnd reram_bitcell_7
Xbit_r10_c58 bl[58] br[58] wl[10] gnd reram_bitcell_7
Xbit_r11_c58 bl[58] br[58] wl[11] gnd reram_bitcell_7
Xbit_r12_c58 bl[58] br[58] wl[12] gnd reram_bitcell_7
Xbit_r13_c58 bl[58] br[58] wl[13] gnd reram_bitcell_7
Xbit_r14_c58 bl[58] br[58] wl[14] gnd reram_bitcell_7
Xbit_r15_c58 bl[58] br[58] wl[15] gnd reram_bitcell_7
Xbit_r16_c58 bl[58] br[58] wl[16] gnd reram_bitcell_7
Xbit_r17_c58 bl[58] br[58] wl[17] gnd reram_bitcell_7
Xbit_r18_c58 bl[58] br[58] wl[18] gnd reram_bitcell_7
Xbit_r19_c58 bl[58] br[58] wl[19] gnd reram_bitcell_7
Xbit_r20_c58 bl[58] br[58] wl[20] gnd reram_bitcell_7
Xbit_r21_c58 bl[58] br[58] wl[21] gnd reram_bitcell_7
Xbit_r22_c58 bl[58] br[58] wl[22] gnd reram_bitcell_7
Xbit_r23_c58 bl[58] br[58] wl[23] gnd reram_bitcell_7
Xbit_r24_c58 bl[58] br[58] wl[24] gnd reram_bitcell_7
Xbit_r25_c58 bl[58] br[58] wl[25] gnd reram_bitcell_7
Xbit_r26_c58 bl[58] br[58] wl[26] gnd reram_bitcell_7
Xbit_r27_c58 bl[58] br[58] wl[27] gnd reram_bitcell_7
Xbit_r28_c58 bl[58] br[58] wl[28] gnd reram_bitcell_7
Xbit_r29_c58 bl[58] br[58] wl[29] gnd reram_bitcell_7
Xbit_r30_c58 bl[58] br[58] wl[30] gnd reram_bitcell_7
Xbit_r31_c58 bl[58] br[58] wl[31] gnd reram_bitcell_7
Xbit_r32_c58 bl[58] br[58] wl[32] gnd reram_bitcell_7
Xbit_r33_c58 bl[58] br[58] wl[33] gnd reram_bitcell_7
Xbit_r34_c58 bl[58] br[58] wl[34] gnd reram_bitcell_7
Xbit_r35_c58 bl[58] br[58] wl[35] gnd reram_bitcell_7
Xbit_r36_c58 bl[58] br[58] wl[36] gnd reram_bitcell_7
Xbit_r37_c58 bl[58] br[58] wl[37] gnd reram_bitcell_7
Xbit_r38_c58 bl[58] br[58] wl[38] gnd reram_bitcell_7
Xbit_r39_c58 bl[58] br[58] wl[39] gnd reram_bitcell_7
Xbit_r40_c58 bl[58] br[58] wl[40] gnd reram_bitcell_7
Xbit_r41_c58 bl[58] br[58] wl[41] gnd reram_bitcell_7
Xbit_r42_c58 bl[58] br[58] wl[42] gnd reram_bitcell_7
Xbit_r43_c58 bl[58] br[58] wl[43] gnd reram_bitcell_7
Xbit_r44_c58 bl[58] br[58] wl[44] gnd reram_bitcell_7
Xbit_r45_c58 bl[58] br[58] wl[45] gnd reram_bitcell_7
Xbit_r46_c58 bl[58] br[58] wl[46] gnd reram_bitcell_7
Xbit_r47_c58 bl[58] br[58] wl[47] gnd reram_bitcell_7
Xbit_r48_c58 bl[58] br[58] wl[48] gnd reram_bitcell_7
Xbit_r49_c58 bl[58] br[58] wl[49] gnd reram_bitcell_7
Xbit_r50_c58 bl[58] br[58] wl[50] gnd reram_bitcell_7
Xbit_r51_c58 bl[58] br[58] wl[51] gnd reram_bitcell_7
Xbit_r52_c58 bl[58] br[58] wl[52] gnd reram_bitcell_7
Xbit_r53_c58 bl[58] br[58] wl[53] gnd reram_bitcell_7
Xbit_r54_c58 bl[58] br[58] wl[54] gnd reram_bitcell_7
Xbit_r55_c58 bl[58] br[58] wl[55] gnd reram_bitcell_7
Xbit_r56_c58 bl[58] br[58] wl[56] gnd reram_bitcell_7
Xbit_r57_c58 bl[58] br[58] wl[57] gnd reram_bitcell_7
Xbit_r58_c58 bl[58] br[58] wl[58] gnd reram_bitcell_7
Xbit_r59_c58 bl[58] br[58] wl[59] gnd reram_bitcell_7
Xbit_r60_c58 bl[58] br[58] wl[60] gnd reram_bitcell_7
Xbit_r61_c58 bl[58] br[58] wl[61] gnd reram_bitcell_7
Xbit_r62_c58 bl[58] br[58] wl[62] gnd reram_bitcell_7
Xbit_r63_c58 bl[58] br[58] wl[63] gnd reram_bitcell_7
Xbit_r0_c59 bl[59] br[59] wl[0] gnd reram_bitcell_7
Xbit_r1_c59 bl[59] br[59] wl[1] gnd reram_bitcell_7
Xbit_r2_c59 bl[59] br[59] wl[2] gnd reram_bitcell_7
Xbit_r3_c59 bl[59] br[59] wl[3] gnd reram_bitcell_7
Xbit_r4_c59 bl[59] br[59] wl[4] gnd reram_bitcell_7
Xbit_r5_c59 bl[59] br[59] wl[5] gnd reram_bitcell_7
Xbit_r6_c59 bl[59] br[59] wl[6] gnd reram_bitcell_7
Xbit_r7_c59 bl[59] br[59] wl[7] gnd reram_bitcell_7
Xbit_r8_c59 bl[59] br[59] wl[8] gnd reram_bitcell_7
Xbit_r9_c59 bl[59] br[59] wl[9] gnd reram_bitcell_7
Xbit_r10_c59 bl[59] br[59] wl[10] gnd reram_bitcell_7
Xbit_r11_c59 bl[59] br[59] wl[11] gnd reram_bitcell_7
Xbit_r12_c59 bl[59] br[59] wl[12] gnd reram_bitcell_7
Xbit_r13_c59 bl[59] br[59] wl[13] gnd reram_bitcell_7
Xbit_r14_c59 bl[59] br[59] wl[14] gnd reram_bitcell_7
Xbit_r15_c59 bl[59] br[59] wl[15] gnd reram_bitcell_7
Xbit_r16_c59 bl[59] br[59] wl[16] gnd reram_bitcell_7
Xbit_r17_c59 bl[59] br[59] wl[17] gnd reram_bitcell_7
Xbit_r18_c59 bl[59] br[59] wl[18] gnd reram_bitcell_7
Xbit_r19_c59 bl[59] br[59] wl[19] gnd reram_bitcell_7
Xbit_r20_c59 bl[59] br[59] wl[20] gnd reram_bitcell_7
Xbit_r21_c59 bl[59] br[59] wl[21] gnd reram_bitcell_7
Xbit_r22_c59 bl[59] br[59] wl[22] gnd reram_bitcell_7
Xbit_r23_c59 bl[59] br[59] wl[23] gnd reram_bitcell_7
Xbit_r24_c59 bl[59] br[59] wl[24] gnd reram_bitcell_7
Xbit_r25_c59 bl[59] br[59] wl[25] gnd reram_bitcell_7
Xbit_r26_c59 bl[59] br[59] wl[26] gnd reram_bitcell_7
Xbit_r27_c59 bl[59] br[59] wl[27] gnd reram_bitcell_7
Xbit_r28_c59 bl[59] br[59] wl[28] gnd reram_bitcell_7
Xbit_r29_c59 bl[59] br[59] wl[29] gnd reram_bitcell_7
Xbit_r30_c59 bl[59] br[59] wl[30] gnd reram_bitcell_7
Xbit_r31_c59 bl[59] br[59] wl[31] gnd reram_bitcell_7
Xbit_r32_c59 bl[59] br[59] wl[32] gnd reram_bitcell_7
Xbit_r33_c59 bl[59] br[59] wl[33] gnd reram_bitcell_7
Xbit_r34_c59 bl[59] br[59] wl[34] gnd reram_bitcell_7
Xbit_r35_c59 bl[59] br[59] wl[35] gnd reram_bitcell_7
Xbit_r36_c59 bl[59] br[59] wl[36] gnd reram_bitcell_7
Xbit_r37_c59 bl[59] br[59] wl[37] gnd reram_bitcell_7
Xbit_r38_c59 bl[59] br[59] wl[38] gnd reram_bitcell_7
Xbit_r39_c59 bl[59] br[59] wl[39] gnd reram_bitcell_7
Xbit_r40_c59 bl[59] br[59] wl[40] gnd reram_bitcell_7
Xbit_r41_c59 bl[59] br[59] wl[41] gnd reram_bitcell_7
Xbit_r42_c59 bl[59] br[59] wl[42] gnd reram_bitcell_7
Xbit_r43_c59 bl[59] br[59] wl[43] gnd reram_bitcell_7
Xbit_r44_c59 bl[59] br[59] wl[44] gnd reram_bitcell_7
Xbit_r45_c59 bl[59] br[59] wl[45] gnd reram_bitcell_7
Xbit_r46_c59 bl[59] br[59] wl[46] gnd reram_bitcell_7
Xbit_r47_c59 bl[59] br[59] wl[47] gnd reram_bitcell_7
Xbit_r48_c59 bl[59] br[59] wl[48] gnd reram_bitcell_7
Xbit_r49_c59 bl[59] br[59] wl[49] gnd reram_bitcell_7
Xbit_r50_c59 bl[59] br[59] wl[50] gnd reram_bitcell_7
Xbit_r51_c59 bl[59] br[59] wl[51] gnd reram_bitcell_7
Xbit_r52_c59 bl[59] br[59] wl[52] gnd reram_bitcell_7
Xbit_r53_c59 bl[59] br[59] wl[53] gnd reram_bitcell_7
Xbit_r54_c59 bl[59] br[59] wl[54] gnd reram_bitcell_7
Xbit_r55_c59 bl[59] br[59] wl[55] gnd reram_bitcell_7
Xbit_r56_c59 bl[59] br[59] wl[56] gnd reram_bitcell_7
Xbit_r57_c59 bl[59] br[59] wl[57] gnd reram_bitcell_7
Xbit_r58_c59 bl[59] br[59] wl[58] gnd reram_bitcell_7
Xbit_r59_c59 bl[59] br[59] wl[59] gnd reram_bitcell_7
Xbit_r60_c59 bl[59] br[59] wl[60] gnd reram_bitcell_7
Xbit_r61_c59 bl[59] br[59] wl[61] gnd reram_bitcell_7
Xbit_r62_c59 bl[59] br[59] wl[62] gnd reram_bitcell_7
Xbit_r63_c59 bl[59] br[59] wl[63] gnd reram_bitcell_7
Xbit_r0_c60 bl[60] br[60] wl[0] gnd reram_bitcell_7
Xbit_r1_c60 bl[60] br[60] wl[1] gnd reram_bitcell_7
Xbit_r2_c60 bl[60] br[60] wl[2] gnd reram_bitcell_7
Xbit_r3_c60 bl[60] br[60] wl[3] gnd reram_bitcell_7
Xbit_r4_c60 bl[60] br[60] wl[4] gnd reram_bitcell_7
Xbit_r5_c60 bl[60] br[60] wl[5] gnd reram_bitcell_7
Xbit_r6_c60 bl[60] br[60] wl[6] gnd reram_bitcell_7
Xbit_r7_c60 bl[60] br[60] wl[7] gnd reram_bitcell_7
Xbit_r8_c60 bl[60] br[60] wl[8] gnd reram_bitcell_7
Xbit_r9_c60 bl[60] br[60] wl[9] gnd reram_bitcell_7
Xbit_r10_c60 bl[60] br[60] wl[10] gnd reram_bitcell_7
Xbit_r11_c60 bl[60] br[60] wl[11] gnd reram_bitcell_7
Xbit_r12_c60 bl[60] br[60] wl[12] gnd reram_bitcell_7
Xbit_r13_c60 bl[60] br[60] wl[13] gnd reram_bitcell_7
Xbit_r14_c60 bl[60] br[60] wl[14] gnd reram_bitcell_7
Xbit_r15_c60 bl[60] br[60] wl[15] gnd reram_bitcell_7
Xbit_r16_c60 bl[60] br[60] wl[16] gnd reram_bitcell_7
Xbit_r17_c60 bl[60] br[60] wl[17] gnd reram_bitcell_7
Xbit_r18_c60 bl[60] br[60] wl[18] gnd reram_bitcell_7
Xbit_r19_c60 bl[60] br[60] wl[19] gnd reram_bitcell_7
Xbit_r20_c60 bl[60] br[60] wl[20] gnd reram_bitcell_7
Xbit_r21_c60 bl[60] br[60] wl[21] gnd reram_bitcell_7
Xbit_r22_c60 bl[60] br[60] wl[22] gnd reram_bitcell_7
Xbit_r23_c60 bl[60] br[60] wl[23] gnd reram_bitcell_7
Xbit_r24_c60 bl[60] br[60] wl[24] gnd reram_bitcell_7
Xbit_r25_c60 bl[60] br[60] wl[25] gnd reram_bitcell_7
Xbit_r26_c60 bl[60] br[60] wl[26] gnd reram_bitcell_7
Xbit_r27_c60 bl[60] br[60] wl[27] gnd reram_bitcell_7
Xbit_r28_c60 bl[60] br[60] wl[28] gnd reram_bitcell_7
Xbit_r29_c60 bl[60] br[60] wl[29] gnd reram_bitcell_7
Xbit_r30_c60 bl[60] br[60] wl[30] gnd reram_bitcell_7
Xbit_r31_c60 bl[60] br[60] wl[31] gnd reram_bitcell_7
Xbit_r32_c60 bl[60] br[60] wl[32] gnd reram_bitcell_7
Xbit_r33_c60 bl[60] br[60] wl[33] gnd reram_bitcell_7
Xbit_r34_c60 bl[60] br[60] wl[34] gnd reram_bitcell_7
Xbit_r35_c60 bl[60] br[60] wl[35] gnd reram_bitcell_7
Xbit_r36_c60 bl[60] br[60] wl[36] gnd reram_bitcell_7
Xbit_r37_c60 bl[60] br[60] wl[37] gnd reram_bitcell_7
Xbit_r38_c60 bl[60] br[60] wl[38] gnd reram_bitcell_7
Xbit_r39_c60 bl[60] br[60] wl[39] gnd reram_bitcell_7
Xbit_r40_c60 bl[60] br[60] wl[40] gnd reram_bitcell_7
Xbit_r41_c60 bl[60] br[60] wl[41] gnd reram_bitcell_7
Xbit_r42_c60 bl[60] br[60] wl[42] gnd reram_bitcell_7
Xbit_r43_c60 bl[60] br[60] wl[43] gnd reram_bitcell_7
Xbit_r44_c60 bl[60] br[60] wl[44] gnd reram_bitcell_7
Xbit_r45_c60 bl[60] br[60] wl[45] gnd reram_bitcell_7
Xbit_r46_c60 bl[60] br[60] wl[46] gnd reram_bitcell_7
Xbit_r47_c60 bl[60] br[60] wl[47] gnd reram_bitcell_7
Xbit_r48_c60 bl[60] br[60] wl[48] gnd reram_bitcell_7
Xbit_r49_c60 bl[60] br[60] wl[49] gnd reram_bitcell_7
Xbit_r50_c60 bl[60] br[60] wl[50] gnd reram_bitcell_7
Xbit_r51_c60 bl[60] br[60] wl[51] gnd reram_bitcell_7
Xbit_r52_c60 bl[60] br[60] wl[52] gnd reram_bitcell_7
Xbit_r53_c60 bl[60] br[60] wl[53] gnd reram_bitcell_7
Xbit_r54_c60 bl[60] br[60] wl[54] gnd reram_bitcell_7
Xbit_r55_c60 bl[60] br[60] wl[55] gnd reram_bitcell_7
Xbit_r56_c60 bl[60] br[60] wl[56] gnd reram_bitcell_7
Xbit_r57_c60 bl[60] br[60] wl[57] gnd reram_bitcell_7
Xbit_r58_c60 bl[60] br[60] wl[58] gnd reram_bitcell_7
Xbit_r59_c60 bl[60] br[60] wl[59] gnd reram_bitcell_7
Xbit_r60_c60 bl[60] br[60] wl[60] gnd reram_bitcell_7
Xbit_r61_c60 bl[60] br[60] wl[61] gnd reram_bitcell_7
Xbit_r62_c60 bl[60] br[60] wl[62] gnd reram_bitcell_7
Xbit_r63_c60 bl[60] br[60] wl[63] gnd reram_bitcell_7
Xbit_r0_c61 bl[61] br[61] wl[0] gnd reram_bitcell_7
Xbit_r1_c61 bl[61] br[61] wl[1] gnd reram_bitcell_7
Xbit_r2_c61 bl[61] br[61] wl[2] gnd reram_bitcell_7
Xbit_r3_c61 bl[61] br[61] wl[3] gnd reram_bitcell_7
Xbit_r4_c61 bl[61] br[61] wl[4] gnd reram_bitcell_7
Xbit_r5_c61 bl[61] br[61] wl[5] gnd reram_bitcell_7
Xbit_r6_c61 bl[61] br[61] wl[6] gnd reram_bitcell_7
Xbit_r7_c61 bl[61] br[61] wl[7] gnd reram_bitcell_7
Xbit_r8_c61 bl[61] br[61] wl[8] gnd reram_bitcell_7
Xbit_r9_c61 bl[61] br[61] wl[9] gnd reram_bitcell_7
Xbit_r10_c61 bl[61] br[61] wl[10] gnd reram_bitcell_7
Xbit_r11_c61 bl[61] br[61] wl[11] gnd reram_bitcell_7
Xbit_r12_c61 bl[61] br[61] wl[12] gnd reram_bitcell_7
Xbit_r13_c61 bl[61] br[61] wl[13] gnd reram_bitcell_7
Xbit_r14_c61 bl[61] br[61] wl[14] gnd reram_bitcell_7
Xbit_r15_c61 bl[61] br[61] wl[15] gnd reram_bitcell_7
Xbit_r16_c61 bl[61] br[61] wl[16] gnd reram_bitcell_7
Xbit_r17_c61 bl[61] br[61] wl[17] gnd reram_bitcell_7
Xbit_r18_c61 bl[61] br[61] wl[18] gnd reram_bitcell_7
Xbit_r19_c61 bl[61] br[61] wl[19] gnd reram_bitcell_7
Xbit_r20_c61 bl[61] br[61] wl[20] gnd reram_bitcell_7
Xbit_r21_c61 bl[61] br[61] wl[21] gnd reram_bitcell_7
Xbit_r22_c61 bl[61] br[61] wl[22] gnd reram_bitcell_7
Xbit_r23_c61 bl[61] br[61] wl[23] gnd reram_bitcell_7
Xbit_r24_c61 bl[61] br[61] wl[24] gnd reram_bitcell_7
Xbit_r25_c61 bl[61] br[61] wl[25] gnd reram_bitcell_7
Xbit_r26_c61 bl[61] br[61] wl[26] gnd reram_bitcell_7
Xbit_r27_c61 bl[61] br[61] wl[27] gnd reram_bitcell_7
Xbit_r28_c61 bl[61] br[61] wl[28] gnd reram_bitcell_7
Xbit_r29_c61 bl[61] br[61] wl[29] gnd reram_bitcell_7
Xbit_r30_c61 bl[61] br[61] wl[30] gnd reram_bitcell_7
Xbit_r31_c61 bl[61] br[61] wl[31] gnd reram_bitcell_7
Xbit_r32_c61 bl[61] br[61] wl[32] gnd reram_bitcell_7
Xbit_r33_c61 bl[61] br[61] wl[33] gnd reram_bitcell_7
Xbit_r34_c61 bl[61] br[61] wl[34] gnd reram_bitcell_7
Xbit_r35_c61 bl[61] br[61] wl[35] gnd reram_bitcell_7
Xbit_r36_c61 bl[61] br[61] wl[36] gnd reram_bitcell_7
Xbit_r37_c61 bl[61] br[61] wl[37] gnd reram_bitcell_7
Xbit_r38_c61 bl[61] br[61] wl[38] gnd reram_bitcell_7
Xbit_r39_c61 bl[61] br[61] wl[39] gnd reram_bitcell_7
Xbit_r40_c61 bl[61] br[61] wl[40] gnd reram_bitcell_7
Xbit_r41_c61 bl[61] br[61] wl[41] gnd reram_bitcell_7
Xbit_r42_c61 bl[61] br[61] wl[42] gnd reram_bitcell_7
Xbit_r43_c61 bl[61] br[61] wl[43] gnd reram_bitcell_7
Xbit_r44_c61 bl[61] br[61] wl[44] gnd reram_bitcell_7
Xbit_r45_c61 bl[61] br[61] wl[45] gnd reram_bitcell_7
Xbit_r46_c61 bl[61] br[61] wl[46] gnd reram_bitcell_7
Xbit_r47_c61 bl[61] br[61] wl[47] gnd reram_bitcell_7
Xbit_r48_c61 bl[61] br[61] wl[48] gnd reram_bitcell_7
Xbit_r49_c61 bl[61] br[61] wl[49] gnd reram_bitcell_7
Xbit_r50_c61 bl[61] br[61] wl[50] gnd reram_bitcell_7
Xbit_r51_c61 bl[61] br[61] wl[51] gnd reram_bitcell_7
Xbit_r52_c61 bl[61] br[61] wl[52] gnd reram_bitcell_7
Xbit_r53_c61 bl[61] br[61] wl[53] gnd reram_bitcell_7
Xbit_r54_c61 bl[61] br[61] wl[54] gnd reram_bitcell_7
Xbit_r55_c61 bl[61] br[61] wl[55] gnd reram_bitcell_7
Xbit_r56_c61 bl[61] br[61] wl[56] gnd reram_bitcell_7
Xbit_r57_c61 bl[61] br[61] wl[57] gnd reram_bitcell_7
Xbit_r58_c61 bl[61] br[61] wl[58] gnd reram_bitcell_7
Xbit_r59_c61 bl[61] br[61] wl[59] gnd reram_bitcell_7
Xbit_r60_c61 bl[61] br[61] wl[60] gnd reram_bitcell_7
Xbit_r61_c61 bl[61] br[61] wl[61] gnd reram_bitcell_7
Xbit_r62_c61 bl[61] br[61] wl[62] gnd reram_bitcell_7
Xbit_r63_c61 bl[61] br[61] wl[63] gnd reram_bitcell_7
Xbit_r0_c62 bl[62] br[62] wl[0] gnd reram_bitcell_7
Xbit_r1_c62 bl[62] br[62] wl[1] gnd reram_bitcell_7
Xbit_r2_c62 bl[62] br[62] wl[2] gnd reram_bitcell_7
Xbit_r3_c62 bl[62] br[62] wl[3] gnd reram_bitcell_7
Xbit_r4_c62 bl[62] br[62] wl[4] gnd reram_bitcell_7
Xbit_r5_c62 bl[62] br[62] wl[5] gnd reram_bitcell_7
Xbit_r6_c62 bl[62] br[62] wl[6] gnd reram_bitcell_7
Xbit_r7_c62 bl[62] br[62] wl[7] gnd reram_bitcell_7
Xbit_r8_c62 bl[62] br[62] wl[8] gnd reram_bitcell_7
Xbit_r9_c62 bl[62] br[62] wl[9] gnd reram_bitcell_7
Xbit_r10_c62 bl[62] br[62] wl[10] gnd reram_bitcell_7
Xbit_r11_c62 bl[62] br[62] wl[11] gnd reram_bitcell_7
Xbit_r12_c62 bl[62] br[62] wl[12] gnd reram_bitcell_7
Xbit_r13_c62 bl[62] br[62] wl[13] gnd reram_bitcell_7
Xbit_r14_c62 bl[62] br[62] wl[14] gnd reram_bitcell_7
Xbit_r15_c62 bl[62] br[62] wl[15] gnd reram_bitcell_7
Xbit_r16_c62 bl[62] br[62] wl[16] gnd reram_bitcell_7
Xbit_r17_c62 bl[62] br[62] wl[17] gnd reram_bitcell_7
Xbit_r18_c62 bl[62] br[62] wl[18] gnd reram_bitcell_7
Xbit_r19_c62 bl[62] br[62] wl[19] gnd reram_bitcell_7
Xbit_r20_c62 bl[62] br[62] wl[20] gnd reram_bitcell_7
Xbit_r21_c62 bl[62] br[62] wl[21] gnd reram_bitcell_7
Xbit_r22_c62 bl[62] br[62] wl[22] gnd reram_bitcell_7
Xbit_r23_c62 bl[62] br[62] wl[23] gnd reram_bitcell_7
Xbit_r24_c62 bl[62] br[62] wl[24] gnd reram_bitcell_7
Xbit_r25_c62 bl[62] br[62] wl[25] gnd reram_bitcell_7
Xbit_r26_c62 bl[62] br[62] wl[26] gnd reram_bitcell_7
Xbit_r27_c62 bl[62] br[62] wl[27] gnd reram_bitcell_7
Xbit_r28_c62 bl[62] br[62] wl[28] gnd reram_bitcell_7
Xbit_r29_c62 bl[62] br[62] wl[29] gnd reram_bitcell_7
Xbit_r30_c62 bl[62] br[62] wl[30] gnd reram_bitcell_7
Xbit_r31_c62 bl[62] br[62] wl[31] gnd reram_bitcell_7
Xbit_r32_c62 bl[62] br[62] wl[32] gnd reram_bitcell_7
Xbit_r33_c62 bl[62] br[62] wl[33] gnd reram_bitcell_7
Xbit_r34_c62 bl[62] br[62] wl[34] gnd reram_bitcell_7
Xbit_r35_c62 bl[62] br[62] wl[35] gnd reram_bitcell_7
Xbit_r36_c62 bl[62] br[62] wl[36] gnd reram_bitcell_7
Xbit_r37_c62 bl[62] br[62] wl[37] gnd reram_bitcell_7
Xbit_r38_c62 bl[62] br[62] wl[38] gnd reram_bitcell_7
Xbit_r39_c62 bl[62] br[62] wl[39] gnd reram_bitcell_7
Xbit_r40_c62 bl[62] br[62] wl[40] gnd reram_bitcell_7
Xbit_r41_c62 bl[62] br[62] wl[41] gnd reram_bitcell_7
Xbit_r42_c62 bl[62] br[62] wl[42] gnd reram_bitcell_7
Xbit_r43_c62 bl[62] br[62] wl[43] gnd reram_bitcell_7
Xbit_r44_c62 bl[62] br[62] wl[44] gnd reram_bitcell_7
Xbit_r45_c62 bl[62] br[62] wl[45] gnd reram_bitcell_7
Xbit_r46_c62 bl[62] br[62] wl[46] gnd reram_bitcell_7
Xbit_r47_c62 bl[62] br[62] wl[47] gnd reram_bitcell_7
Xbit_r48_c62 bl[62] br[62] wl[48] gnd reram_bitcell_7
Xbit_r49_c62 bl[62] br[62] wl[49] gnd reram_bitcell_7
Xbit_r50_c62 bl[62] br[62] wl[50] gnd reram_bitcell_7
Xbit_r51_c62 bl[62] br[62] wl[51] gnd reram_bitcell_7
Xbit_r52_c62 bl[62] br[62] wl[52] gnd reram_bitcell_7
Xbit_r53_c62 bl[62] br[62] wl[53] gnd reram_bitcell_7
Xbit_r54_c62 bl[62] br[62] wl[54] gnd reram_bitcell_7
Xbit_r55_c62 bl[62] br[62] wl[55] gnd reram_bitcell_7
Xbit_r56_c62 bl[62] br[62] wl[56] gnd reram_bitcell_7
Xbit_r57_c62 bl[62] br[62] wl[57] gnd reram_bitcell_7
Xbit_r58_c62 bl[62] br[62] wl[58] gnd reram_bitcell_7
Xbit_r59_c62 bl[62] br[62] wl[59] gnd reram_bitcell_7
Xbit_r60_c62 bl[62] br[62] wl[60] gnd reram_bitcell_7
Xbit_r61_c62 bl[62] br[62] wl[61] gnd reram_bitcell_7
Xbit_r62_c62 bl[62] br[62] wl[62] gnd reram_bitcell_7
Xbit_r63_c62 bl[62] br[62] wl[63] gnd reram_bitcell_7
Xbit_r0_c63 bl[63] br[63] wl[0] gnd reram_bitcell_7
Xbit_r1_c63 bl[63] br[63] wl[1] gnd reram_bitcell_7
Xbit_r2_c63 bl[63] br[63] wl[2] gnd reram_bitcell_7
Xbit_r3_c63 bl[63] br[63] wl[3] gnd reram_bitcell_7
Xbit_r4_c63 bl[63] br[63] wl[4] gnd reram_bitcell_7
Xbit_r5_c63 bl[63] br[63] wl[5] gnd reram_bitcell_7
Xbit_r6_c63 bl[63] br[63] wl[6] gnd reram_bitcell_7
Xbit_r7_c63 bl[63] br[63] wl[7] gnd reram_bitcell_7
Xbit_r8_c63 bl[63] br[63] wl[8] gnd reram_bitcell_7
Xbit_r9_c63 bl[63] br[63] wl[9] gnd reram_bitcell_7
Xbit_r10_c63 bl[63] br[63] wl[10] gnd reram_bitcell_7
Xbit_r11_c63 bl[63] br[63] wl[11] gnd reram_bitcell_7
Xbit_r12_c63 bl[63] br[63] wl[12] gnd reram_bitcell_7
Xbit_r13_c63 bl[63] br[63] wl[13] gnd reram_bitcell_7
Xbit_r14_c63 bl[63] br[63] wl[14] gnd reram_bitcell_7
Xbit_r15_c63 bl[63] br[63] wl[15] gnd reram_bitcell_7
Xbit_r16_c63 bl[63] br[63] wl[16] gnd reram_bitcell_7
Xbit_r17_c63 bl[63] br[63] wl[17] gnd reram_bitcell_7
Xbit_r18_c63 bl[63] br[63] wl[18] gnd reram_bitcell_7
Xbit_r19_c63 bl[63] br[63] wl[19] gnd reram_bitcell_7
Xbit_r20_c63 bl[63] br[63] wl[20] gnd reram_bitcell_7
Xbit_r21_c63 bl[63] br[63] wl[21] gnd reram_bitcell_7
Xbit_r22_c63 bl[63] br[63] wl[22] gnd reram_bitcell_7
Xbit_r23_c63 bl[63] br[63] wl[23] gnd reram_bitcell_7
Xbit_r24_c63 bl[63] br[63] wl[24] gnd reram_bitcell_7
Xbit_r25_c63 bl[63] br[63] wl[25] gnd reram_bitcell_7
Xbit_r26_c63 bl[63] br[63] wl[26] gnd reram_bitcell_7
Xbit_r27_c63 bl[63] br[63] wl[27] gnd reram_bitcell_7
Xbit_r28_c63 bl[63] br[63] wl[28] gnd reram_bitcell_7
Xbit_r29_c63 bl[63] br[63] wl[29] gnd reram_bitcell_7
Xbit_r30_c63 bl[63] br[63] wl[30] gnd reram_bitcell_7
Xbit_r31_c63 bl[63] br[63] wl[31] gnd reram_bitcell_7
Xbit_r32_c63 bl[63] br[63] wl[32] gnd reram_bitcell_7
Xbit_r33_c63 bl[63] br[63] wl[33] gnd reram_bitcell_7
Xbit_r34_c63 bl[63] br[63] wl[34] gnd reram_bitcell_7
Xbit_r35_c63 bl[63] br[63] wl[35] gnd reram_bitcell_7
Xbit_r36_c63 bl[63] br[63] wl[36] gnd reram_bitcell_7
Xbit_r37_c63 bl[63] br[63] wl[37] gnd reram_bitcell_7
Xbit_r38_c63 bl[63] br[63] wl[38] gnd reram_bitcell_7
Xbit_r39_c63 bl[63] br[63] wl[39] gnd reram_bitcell_7
Xbit_r40_c63 bl[63] br[63] wl[40] gnd reram_bitcell_7
Xbit_r41_c63 bl[63] br[63] wl[41] gnd reram_bitcell_7
Xbit_r42_c63 bl[63] br[63] wl[42] gnd reram_bitcell_7
Xbit_r43_c63 bl[63] br[63] wl[43] gnd reram_bitcell_7
Xbit_r44_c63 bl[63] br[63] wl[44] gnd reram_bitcell_7
Xbit_r45_c63 bl[63] br[63] wl[45] gnd reram_bitcell_7
Xbit_r46_c63 bl[63] br[63] wl[46] gnd reram_bitcell_7
Xbit_r47_c63 bl[63] br[63] wl[47] gnd reram_bitcell_7
Xbit_r48_c63 bl[63] br[63] wl[48] gnd reram_bitcell_7
Xbit_r49_c63 bl[63] br[63] wl[49] gnd reram_bitcell_7
Xbit_r50_c63 bl[63] br[63] wl[50] gnd reram_bitcell_7
Xbit_r51_c63 bl[63] br[63] wl[51] gnd reram_bitcell_7
Xbit_r52_c63 bl[63] br[63] wl[52] gnd reram_bitcell_7
Xbit_r53_c63 bl[63] br[63] wl[53] gnd reram_bitcell_7
Xbit_r54_c63 bl[63] br[63] wl[54] gnd reram_bitcell_7
Xbit_r55_c63 bl[63] br[63] wl[55] gnd reram_bitcell_7
Xbit_r56_c63 bl[63] br[63] wl[56] gnd reram_bitcell_7
Xbit_r57_c63 bl[63] br[63] wl[57] gnd reram_bitcell_7
Xbit_r58_c63 bl[63] br[63] wl[58] gnd reram_bitcell_7
Xbit_r59_c63 bl[63] br[63] wl[59] gnd reram_bitcell_7
Xbit_r60_c63 bl[63] br[63] wl[60] gnd reram_bitcell_7
Xbit_r61_c63 bl[63] br[63] wl[61] gnd reram_bitcell_7
Xbit_r62_c63 bl[63] br[63] wl[62] gnd reram_bitcell_7
Xbit_r63_c63 bl[63] br[63] wl[63] gnd reram_bitcell_7
Xbit_r0_c64 bl[64] br[64] wl[0] gnd reram_bitcell_7
Xbit_r1_c64 bl[64] br[64] wl[1] gnd reram_bitcell_7
Xbit_r2_c64 bl[64] br[64] wl[2] gnd reram_bitcell_7
Xbit_r3_c64 bl[64] br[64] wl[3] gnd reram_bitcell_7
Xbit_r4_c64 bl[64] br[64] wl[4] gnd reram_bitcell_7
Xbit_r5_c64 bl[64] br[64] wl[5] gnd reram_bitcell_7
Xbit_r6_c64 bl[64] br[64] wl[6] gnd reram_bitcell_7
Xbit_r7_c64 bl[64] br[64] wl[7] gnd reram_bitcell_7
Xbit_r8_c64 bl[64] br[64] wl[8] gnd reram_bitcell_7
Xbit_r9_c64 bl[64] br[64] wl[9] gnd reram_bitcell_7
Xbit_r10_c64 bl[64] br[64] wl[10] gnd reram_bitcell_7
Xbit_r11_c64 bl[64] br[64] wl[11] gnd reram_bitcell_7
Xbit_r12_c64 bl[64] br[64] wl[12] gnd reram_bitcell_7
Xbit_r13_c64 bl[64] br[64] wl[13] gnd reram_bitcell_7
Xbit_r14_c64 bl[64] br[64] wl[14] gnd reram_bitcell_7
Xbit_r15_c64 bl[64] br[64] wl[15] gnd reram_bitcell_7
Xbit_r16_c64 bl[64] br[64] wl[16] gnd reram_bitcell_7
Xbit_r17_c64 bl[64] br[64] wl[17] gnd reram_bitcell_7
Xbit_r18_c64 bl[64] br[64] wl[18] gnd reram_bitcell_7
Xbit_r19_c64 bl[64] br[64] wl[19] gnd reram_bitcell_7
Xbit_r20_c64 bl[64] br[64] wl[20] gnd reram_bitcell_7
Xbit_r21_c64 bl[64] br[64] wl[21] gnd reram_bitcell_7
Xbit_r22_c64 bl[64] br[64] wl[22] gnd reram_bitcell_7
Xbit_r23_c64 bl[64] br[64] wl[23] gnd reram_bitcell_7
Xbit_r24_c64 bl[64] br[64] wl[24] gnd reram_bitcell_7
Xbit_r25_c64 bl[64] br[64] wl[25] gnd reram_bitcell_7
Xbit_r26_c64 bl[64] br[64] wl[26] gnd reram_bitcell_7
Xbit_r27_c64 bl[64] br[64] wl[27] gnd reram_bitcell_7
Xbit_r28_c64 bl[64] br[64] wl[28] gnd reram_bitcell_7
Xbit_r29_c64 bl[64] br[64] wl[29] gnd reram_bitcell_7
Xbit_r30_c64 bl[64] br[64] wl[30] gnd reram_bitcell_7
Xbit_r31_c64 bl[64] br[64] wl[31] gnd reram_bitcell_7
Xbit_r32_c64 bl[64] br[64] wl[32] gnd reram_bitcell_7
Xbit_r33_c64 bl[64] br[64] wl[33] gnd reram_bitcell_7
Xbit_r34_c64 bl[64] br[64] wl[34] gnd reram_bitcell_7
Xbit_r35_c64 bl[64] br[64] wl[35] gnd reram_bitcell_7
Xbit_r36_c64 bl[64] br[64] wl[36] gnd reram_bitcell_7
Xbit_r37_c64 bl[64] br[64] wl[37] gnd reram_bitcell_7
Xbit_r38_c64 bl[64] br[64] wl[38] gnd reram_bitcell_7
Xbit_r39_c64 bl[64] br[64] wl[39] gnd reram_bitcell_7
Xbit_r40_c64 bl[64] br[64] wl[40] gnd reram_bitcell_7
Xbit_r41_c64 bl[64] br[64] wl[41] gnd reram_bitcell_7
Xbit_r42_c64 bl[64] br[64] wl[42] gnd reram_bitcell_7
Xbit_r43_c64 bl[64] br[64] wl[43] gnd reram_bitcell_7
Xbit_r44_c64 bl[64] br[64] wl[44] gnd reram_bitcell_7
Xbit_r45_c64 bl[64] br[64] wl[45] gnd reram_bitcell_7
Xbit_r46_c64 bl[64] br[64] wl[46] gnd reram_bitcell_7
Xbit_r47_c64 bl[64] br[64] wl[47] gnd reram_bitcell_7
Xbit_r48_c64 bl[64] br[64] wl[48] gnd reram_bitcell_7
Xbit_r49_c64 bl[64] br[64] wl[49] gnd reram_bitcell_7
Xbit_r50_c64 bl[64] br[64] wl[50] gnd reram_bitcell_7
Xbit_r51_c64 bl[64] br[64] wl[51] gnd reram_bitcell_7
Xbit_r52_c64 bl[64] br[64] wl[52] gnd reram_bitcell_7
Xbit_r53_c64 bl[64] br[64] wl[53] gnd reram_bitcell_7
Xbit_r54_c64 bl[64] br[64] wl[54] gnd reram_bitcell_7
Xbit_r55_c64 bl[64] br[64] wl[55] gnd reram_bitcell_7
Xbit_r56_c64 bl[64] br[64] wl[56] gnd reram_bitcell_7
Xbit_r57_c64 bl[64] br[64] wl[57] gnd reram_bitcell_7
Xbit_r58_c64 bl[64] br[64] wl[58] gnd reram_bitcell_7
Xbit_r59_c64 bl[64] br[64] wl[59] gnd reram_bitcell_7
Xbit_r60_c64 bl[64] br[64] wl[60] gnd reram_bitcell_7
Xbit_r61_c64 bl[64] br[64] wl[61] gnd reram_bitcell_7
Xbit_r62_c64 bl[64] br[64] wl[62] gnd reram_bitcell_7
Xbit_r63_c64 bl[64] br[64] wl[63] gnd reram_bitcell_7
Xbit_r0_c65 bl[65] br[65] wl[0] gnd reram_bitcell_7
Xbit_r1_c65 bl[65] br[65] wl[1] gnd reram_bitcell_7
Xbit_r2_c65 bl[65] br[65] wl[2] gnd reram_bitcell_7
Xbit_r3_c65 bl[65] br[65] wl[3] gnd reram_bitcell_7
Xbit_r4_c65 bl[65] br[65] wl[4] gnd reram_bitcell_7
Xbit_r5_c65 bl[65] br[65] wl[5] gnd reram_bitcell_7
Xbit_r6_c65 bl[65] br[65] wl[6] gnd reram_bitcell_7
Xbit_r7_c65 bl[65] br[65] wl[7] gnd reram_bitcell_7
Xbit_r8_c65 bl[65] br[65] wl[8] gnd reram_bitcell_7
Xbit_r9_c65 bl[65] br[65] wl[9] gnd reram_bitcell_7
Xbit_r10_c65 bl[65] br[65] wl[10] gnd reram_bitcell_7
Xbit_r11_c65 bl[65] br[65] wl[11] gnd reram_bitcell_7
Xbit_r12_c65 bl[65] br[65] wl[12] gnd reram_bitcell_7
Xbit_r13_c65 bl[65] br[65] wl[13] gnd reram_bitcell_7
Xbit_r14_c65 bl[65] br[65] wl[14] gnd reram_bitcell_7
Xbit_r15_c65 bl[65] br[65] wl[15] gnd reram_bitcell_7
Xbit_r16_c65 bl[65] br[65] wl[16] gnd reram_bitcell_7
Xbit_r17_c65 bl[65] br[65] wl[17] gnd reram_bitcell_7
Xbit_r18_c65 bl[65] br[65] wl[18] gnd reram_bitcell_7
Xbit_r19_c65 bl[65] br[65] wl[19] gnd reram_bitcell_7
Xbit_r20_c65 bl[65] br[65] wl[20] gnd reram_bitcell_7
Xbit_r21_c65 bl[65] br[65] wl[21] gnd reram_bitcell_7
Xbit_r22_c65 bl[65] br[65] wl[22] gnd reram_bitcell_7
Xbit_r23_c65 bl[65] br[65] wl[23] gnd reram_bitcell_7
Xbit_r24_c65 bl[65] br[65] wl[24] gnd reram_bitcell_7
Xbit_r25_c65 bl[65] br[65] wl[25] gnd reram_bitcell_7
Xbit_r26_c65 bl[65] br[65] wl[26] gnd reram_bitcell_7
Xbit_r27_c65 bl[65] br[65] wl[27] gnd reram_bitcell_7
Xbit_r28_c65 bl[65] br[65] wl[28] gnd reram_bitcell_7
Xbit_r29_c65 bl[65] br[65] wl[29] gnd reram_bitcell_7
Xbit_r30_c65 bl[65] br[65] wl[30] gnd reram_bitcell_7
Xbit_r31_c65 bl[65] br[65] wl[31] gnd reram_bitcell_7
Xbit_r32_c65 bl[65] br[65] wl[32] gnd reram_bitcell_7
Xbit_r33_c65 bl[65] br[65] wl[33] gnd reram_bitcell_7
Xbit_r34_c65 bl[65] br[65] wl[34] gnd reram_bitcell_7
Xbit_r35_c65 bl[65] br[65] wl[35] gnd reram_bitcell_7
Xbit_r36_c65 bl[65] br[65] wl[36] gnd reram_bitcell_7
Xbit_r37_c65 bl[65] br[65] wl[37] gnd reram_bitcell_7
Xbit_r38_c65 bl[65] br[65] wl[38] gnd reram_bitcell_7
Xbit_r39_c65 bl[65] br[65] wl[39] gnd reram_bitcell_7
Xbit_r40_c65 bl[65] br[65] wl[40] gnd reram_bitcell_7
Xbit_r41_c65 bl[65] br[65] wl[41] gnd reram_bitcell_7
Xbit_r42_c65 bl[65] br[65] wl[42] gnd reram_bitcell_7
Xbit_r43_c65 bl[65] br[65] wl[43] gnd reram_bitcell_7
Xbit_r44_c65 bl[65] br[65] wl[44] gnd reram_bitcell_7
Xbit_r45_c65 bl[65] br[65] wl[45] gnd reram_bitcell_7
Xbit_r46_c65 bl[65] br[65] wl[46] gnd reram_bitcell_7
Xbit_r47_c65 bl[65] br[65] wl[47] gnd reram_bitcell_7
Xbit_r48_c65 bl[65] br[65] wl[48] gnd reram_bitcell_7
Xbit_r49_c65 bl[65] br[65] wl[49] gnd reram_bitcell_7
Xbit_r50_c65 bl[65] br[65] wl[50] gnd reram_bitcell_7
Xbit_r51_c65 bl[65] br[65] wl[51] gnd reram_bitcell_7
Xbit_r52_c65 bl[65] br[65] wl[52] gnd reram_bitcell_7
Xbit_r53_c65 bl[65] br[65] wl[53] gnd reram_bitcell_7
Xbit_r54_c65 bl[65] br[65] wl[54] gnd reram_bitcell_7
Xbit_r55_c65 bl[65] br[65] wl[55] gnd reram_bitcell_7
Xbit_r56_c65 bl[65] br[65] wl[56] gnd reram_bitcell_7
Xbit_r57_c65 bl[65] br[65] wl[57] gnd reram_bitcell_7
Xbit_r58_c65 bl[65] br[65] wl[58] gnd reram_bitcell_7
Xbit_r59_c65 bl[65] br[65] wl[59] gnd reram_bitcell_7
Xbit_r60_c65 bl[65] br[65] wl[60] gnd reram_bitcell_7
Xbit_r61_c65 bl[65] br[65] wl[61] gnd reram_bitcell_7
Xbit_r62_c65 bl[65] br[65] wl[62] gnd reram_bitcell_7
Xbit_r63_c65 bl[65] br[65] wl[63] gnd reram_bitcell_7
Xbit_r0_c66 bl[66] br[66] wl[0] gnd reram_bitcell_7
Xbit_r1_c66 bl[66] br[66] wl[1] gnd reram_bitcell_7
Xbit_r2_c66 bl[66] br[66] wl[2] gnd reram_bitcell_7
Xbit_r3_c66 bl[66] br[66] wl[3] gnd reram_bitcell_7
Xbit_r4_c66 bl[66] br[66] wl[4] gnd reram_bitcell_7
Xbit_r5_c66 bl[66] br[66] wl[5] gnd reram_bitcell_7
Xbit_r6_c66 bl[66] br[66] wl[6] gnd reram_bitcell_7
Xbit_r7_c66 bl[66] br[66] wl[7] gnd reram_bitcell_7
Xbit_r8_c66 bl[66] br[66] wl[8] gnd reram_bitcell_7
Xbit_r9_c66 bl[66] br[66] wl[9] gnd reram_bitcell_7
Xbit_r10_c66 bl[66] br[66] wl[10] gnd reram_bitcell_7
Xbit_r11_c66 bl[66] br[66] wl[11] gnd reram_bitcell_7
Xbit_r12_c66 bl[66] br[66] wl[12] gnd reram_bitcell_7
Xbit_r13_c66 bl[66] br[66] wl[13] gnd reram_bitcell_7
Xbit_r14_c66 bl[66] br[66] wl[14] gnd reram_bitcell_7
Xbit_r15_c66 bl[66] br[66] wl[15] gnd reram_bitcell_7
Xbit_r16_c66 bl[66] br[66] wl[16] gnd reram_bitcell_7
Xbit_r17_c66 bl[66] br[66] wl[17] gnd reram_bitcell_7
Xbit_r18_c66 bl[66] br[66] wl[18] gnd reram_bitcell_7
Xbit_r19_c66 bl[66] br[66] wl[19] gnd reram_bitcell_7
Xbit_r20_c66 bl[66] br[66] wl[20] gnd reram_bitcell_7
Xbit_r21_c66 bl[66] br[66] wl[21] gnd reram_bitcell_7
Xbit_r22_c66 bl[66] br[66] wl[22] gnd reram_bitcell_7
Xbit_r23_c66 bl[66] br[66] wl[23] gnd reram_bitcell_7
Xbit_r24_c66 bl[66] br[66] wl[24] gnd reram_bitcell_7
Xbit_r25_c66 bl[66] br[66] wl[25] gnd reram_bitcell_7
Xbit_r26_c66 bl[66] br[66] wl[26] gnd reram_bitcell_7
Xbit_r27_c66 bl[66] br[66] wl[27] gnd reram_bitcell_7
Xbit_r28_c66 bl[66] br[66] wl[28] gnd reram_bitcell_7
Xbit_r29_c66 bl[66] br[66] wl[29] gnd reram_bitcell_7
Xbit_r30_c66 bl[66] br[66] wl[30] gnd reram_bitcell_7
Xbit_r31_c66 bl[66] br[66] wl[31] gnd reram_bitcell_7
Xbit_r32_c66 bl[66] br[66] wl[32] gnd reram_bitcell_7
Xbit_r33_c66 bl[66] br[66] wl[33] gnd reram_bitcell_7
Xbit_r34_c66 bl[66] br[66] wl[34] gnd reram_bitcell_7
Xbit_r35_c66 bl[66] br[66] wl[35] gnd reram_bitcell_7
Xbit_r36_c66 bl[66] br[66] wl[36] gnd reram_bitcell_7
Xbit_r37_c66 bl[66] br[66] wl[37] gnd reram_bitcell_7
Xbit_r38_c66 bl[66] br[66] wl[38] gnd reram_bitcell_7
Xbit_r39_c66 bl[66] br[66] wl[39] gnd reram_bitcell_7
Xbit_r40_c66 bl[66] br[66] wl[40] gnd reram_bitcell_7
Xbit_r41_c66 bl[66] br[66] wl[41] gnd reram_bitcell_7
Xbit_r42_c66 bl[66] br[66] wl[42] gnd reram_bitcell_7
Xbit_r43_c66 bl[66] br[66] wl[43] gnd reram_bitcell_7
Xbit_r44_c66 bl[66] br[66] wl[44] gnd reram_bitcell_7
Xbit_r45_c66 bl[66] br[66] wl[45] gnd reram_bitcell_7
Xbit_r46_c66 bl[66] br[66] wl[46] gnd reram_bitcell_7
Xbit_r47_c66 bl[66] br[66] wl[47] gnd reram_bitcell_7
Xbit_r48_c66 bl[66] br[66] wl[48] gnd reram_bitcell_7
Xbit_r49_c66 bl[66] br[66] wl[49] gnd reram_bitcell_7
Xbit_r50_c66 bl[66] br[66] wl[50] gnd reram_bitcell_7
Xbit_r51_c66 bl[66] br[66] wl[51] gnd reram_bitcell_7
Xbit_r52_c66 bl[66] br[66] wl[52] gnd reram_bitcell_7
Xbit_r53_c66 bl[66] br[66] wl[53] gnd reram_bitcell_7
Xbit_r54_c66 bl[66] br[66] wl[54] gnd reram_bitcell_7
Xbit_r55_c66 bl[66] br[66] wl[55] gnd reram_bitcell_7
Xbit_r56_c66 bl[66] br[66] wl[56] gnd reram_bitcell_7
Xbit_r57_c66 bl[66] br[66] wl[57] gnd reram_bitcell_7
Xbit_r58_c66 bl[66] br[66] wl[58] gnd reram_bitcell_7
Xbit_r59_c66 bl[66] br[66] wl[59] gnd reram_bitcell_7
Xbit_r60_c66 bl[66] br[66] wl[60] gnd reram_bitcell_7
Xbit_r61_c66 bl[66] br[66] wl[61] gnd reram_bitcell_7
Xbit_r62_c66 bl[66] br[66] wl[62] gnd reram_bitcell_7
Xbit_r63_c66 bl[66] br[66] wl[63] gnd reram_bitcell_7
Xbit_r0_c67 bl[67] br[67] wl[0] gnd reram_bitcell_7
Xbit_r1_c67 bl[67] br[67] wl[1] gnd reram_bitcell_7
Xbit_r2_c67 bl[67] br[67] wl[2] gnd reram_bitcell_7
Xbit_r3_c67 bl[67] br[67] wl[3] gnd reram_bitcell_7
Xbit_r4_c67 bl[67] br[67] wl[4] gnd reram_bitcell_7
Xbit_r5_c67 bl[67] br[67] wl[5] gnd reram_bitcell_7
Xbit_r6_c67 bl[67] br[67] wl[6] gnd reram_bitcell_7
Xbit_r7_c67 bl[67] br[67] wl[7] gnd reram_bitcell_7
Xbit_r8_c67 bl[67] br[67] wl[8] gnd reram_bitcell_7
Xbit_r9_c67 bl[67] br[67] wl[9] gnd reram_bitcell_7
Xbit_r10_c67 bl[67] br[67] wl[10] gnd reram_bitcell_7
Xbit_r11_c67 bl[67] br[67] wl[11] gnd reram_bitcell_7
Xbit_r12_c67 bl[67] br[67] wl[12] gnd reram_bitcell_7
Xbit_r13_c67 bl[67] br[67] wl[13] gnd reram_bitcell_7
Xbit_r14_c67 bl[67] br[67] wl[14] gnd reram_bitcell_7
Xbit_r15_c67 bl[67] br[67] wl[15] gnd reram_bitcell_7
Xbit_r16_c67 bl[67] br[67] wl[16] gnd reram_bitcell_7
Xbit_r17_c67 bl[67] br[67] wl[17] gnd reram_bitcell_7
Xbit_r18_c67 bl[67] br[67] wl[18] gnd reram_bitcell_7
Xbit_r19_c67 bl[67] br[67] wl[19] gnd reram_bitcell_7
Xbit_r20_c67 bl[67] br[67] wl[20] gnd reram_bitcell_7
Xbit_r21_c67 bl[67] br[67] wl[21] gnd reram_bitcell_7
Xbit_r22_c67 bl[67] br[67] wl[22] gnd reram_bitcell_7
Xbit_r23_c67 bl[67] br[67] wl[23] gnd reram_bitcell_7
Xbit_r24_c67 bl[67] br[67] wl[24] gnd reram_bitcell_7
Xbit_r25_c67 bl[67] br[67] wl[25] gnd reram_bitcell_7
Xbit_r26_c67 bl[67] br[67] wl[26] gnd reram_bitcell_7
Xbit_r27_c67 bl[67] br[67] wl[27] gnd reram_bitcell_7
Xbit_r28_c67 bl[67] br[67] wl[28] gnd reram_bitcell_7
Xbit_r29_c67 bl[67] br[67] wl[29] gnd reram_bitcell_7
Xbit_r30_c67 bl[67] br[67] wl[30] gnd reram_bitcell_7
Xbit_r31_c67 bl[67] br[67] wl[31] gnd reram_bitcell_7
Xbit_r32_c67 bl[67] br[67] wl[32] gnd reram_bitcell_7
Xbit_r33_c67 bl[67] br[67] wl[33] gnd reram_bitcell_7
Xbit_r34_c67 bl[67] br[67] wl[34] gnd reram_bitcell_7
Xbit_r35_c67 bl[67] br[67] wl[35] gnd reram_bitcell_7
Xbit_r36_c67 bl[67] br[67] wl[36] gnd reram_bitcell_7
Xbit_r37_c67 bl[67] br[67] wl[37] gnd reram_bitcell_7
Xbit_r38_c67 bl[67] br[67] wl[38] gnd reram_bitcell_7
Xbit_r39_c67 bl[67] br[67] wl[39] gnd reram_bitcell_7
Xbit_r40_c67 bl[67] br[67] wl[40] gnd reram_bitcell_7
Xbit_r41_c67 bl[67] br[67] wl[41] gnd reram_bitcell_7
Xbit_r42_c67 bl[67] br[67] wl[42] gnd reram_bitcell_7
Xbit_r43_c67 bl[67] br[67] wl[43] gnd reram_bitcell_7
Xbit_r44_c67 bl[67] br[67] wl[44] gnd reram_bitcell_7
Xbit_r45_c67 bl[67] br[67] wl[45] gnd reram_bitcell_7
Xbit_r46_c67 bl[67] br[67] wl[46] gnd reram_bitcell_7
Xbit_r47_c67 bl[67] br[67] wl[47] gnd reram_bitcell_7
Xbit_r48_c67 bl[67] br[67] wl[48] gnd reram_bitcell_7
Xbit_r49_c67 bl[67] br[67] wl[49] gnd reram_bitcell_7
Xbit_r50_c67 bl[67] br[67] wl[50] gnd reram_bitcell_7
Xbit_r51_c67 bl[67] br[67] wl[51] gnd reram_bitcell_7
Xbit_r52_c67 bl[67] br[67] wl[52] gnd reram_bitcell_7
Xbit_r53_c67 bl[67] br[67] wl[53] gnd reram_bitcell_7
Xbit_r54_c67 bl[67] br[67] wl[54] gnd reram_bitcell_7
Xbit_r55_c67 bl[67] br[67] wl[55] gnd reram_bitcell_7
Xbit_r56_c67 bl[67] br[67] wl[56] gnd reram_bitcell_7
Xbit_r57_c67 bl[67] br[67] wl[57] gnd reram_bitcell_7
Xbit_r58_c67 bl[67] br[67] wl[58] gnd reram_bitcell_7
Xbit_r59_c67 bl[67] br[67] wl[59] gnd reram_bitcell_7
Xbit_r60_c67 bl[67] br[67] wl[60] gnd reram_bitcell_7
Xbit_r61_c67 bl[67] br[67] wl[61] gnd reram_bitcell_7
Xbit_r62_c67 bl[67] br[67] wl[62] gnd reram_bitcell_7
Xbit_r63_c67 bl[67] br[67] wl[63] gnd reram_bitcell_7
Xbit_r0_c68 bl[68] br[68] wl[0] gnd reram_bitcell_7
Xbit_r1_c68 bl[68] br[68] wl[1] gnd reram_bitcell_7
Xbit_r2_c68 bl[68] br[68] wl[2] gnd reram_bitcell_7
Xbit_r3_c68 bl[68] br[68] wl[3] gnd reram_bitcell_7
Xbit_r4_c68 bl[68] br[68] wl[4] gnd reram_bitcell_7
Xbit_r5_c68 bl[68] br[68] wl[5] gnd reram_bitcell_7
Xbit_r6_c68 bl[68] br[68] wl[6] gnd reram_bitcell_7
Xbit_r7_c68 bl[68] br[68] wl[7] gnd reram_bitcell_7
Xbit_r8_c68 bl[68] br[68] wl[8] gnd reram_bitcell_7
Xbit_r9_c68 bl[68] br[68] wl[9] gnd reram_bitcell_7
Xbit_r10_c68 bl[68] br[68] wl[10] gnd reram_bitcell_7
Xbit_r11_c68 bl[68] br[68] wl[11] gnd reram_bitcell_7
Xbit_r12_c68 bl[68] br[68] wl[12] gnd reram_bitcell_7
Xbit_r13_c68 bl[68] br[68] wl[13] gnd reram_bitcell_7
Xbit_r14_c68 bl[68] br[68] wl[14] gnd reram_bitcell_7
Xbit_r15_c68 bl[68] br[68] wl[15] gnd reram_bitcell_7
Xbit_r16_c68 bl[68] br[68] wl[16] gnd reram_bitcell_7
Xbit_r17_c68 bl[68] br[68] wl[17] gnd reram_bitcell_7
Xbit_r18_c68 bl[68] br[68] wl[18] gnd reram_bitcell_7
Xbit_r19_c68 bl[68] br[68] wl[19] gnd reram_bitcell_7
Xbit_r20_c68 bl[68] br[68] wl[20] gnd reram_bitcell_7
Xbit_r21_c68 bl[68] br[68] wl[21] gnd reram_bitcell_7
Xbit_r22_c68 bl[68] br[68] wl[22] gnd reram_bitcell_7
Xbit_r23_c68 bl[68] br[68] wl[23] gnd reram_bitcell_7
Xbit_r24_c68 bl[68] br[68] wl[24] gnd reram_bitcell_7
Xbit_r25_c68 bl[68] br[68] wl[25] gnd reram_bitcell_7
Xbit_r26_c68 bl[68] br[68] wl[26] gnd reram_bitcell_7
Xbit_r27_c68 bl[68] br[68] wl[27] gnd reram_bitcell_7
Xbit_r28_c68 bl[68] br[68] wl[28] gnd reram_bitcell_7
Xbit_r29_c68 bl[68] br[68] wl[29] gnd reram_bitcell_7
Xbit_r30_c68 bl[68] br[68] wl[30] gnd reram_bitcell_7
Xbit_r31_c68 bl[68] br[68] wl[31] gnd reram_bitcell_7
Xbit_r32_c68 bl[68] br[68] wl[32] gnd reram_bitcell_7
Xbit_r33_c68 bl[68] br[68] wl[33] gnd reram_bitcell_7
Xbit_r34_c68 bl[68] br[68] wl[34] gnd reram_bitcell_7
Xbit_r35_c68 bl[68] br[68] wl[35] gnd reram_bitcell_7
Xbit_r36_c68 bl[68] br[68] wl[36] gnd reram_bitcell_7
Xbit_r37_c68 bl[68] br[68] wl[37] gnd reram_bitcell_7
Xbit_r38_c68 bl[68] br[68] wl[38] gnd reram_bitcell_7
Xbit_r39_c68 bl[68] br[68] wl[39] gnd reram_bitcell_7
Xbit_r40_c68 bl[68] br[68] wl[40] gnd reram_bitcell_7
Xbit_r41_c68 bl[68] br[68] wl[41] gnd reram_bitcell_7
Xbit_r42_c68 bl[68] br[68] wl[42] gnd reram_bitcell_7
Xbit_r43_c68 bl[68] br[68] wl[43] gnd reram_bitcell_7
Xbit_r44_c68 bl[68] br[68] wl[44] gnd reram_bitcell_7
Xbit_r45_c68 bl[68] br[68] wl[45] gnd reram_bitcell_7
Xbit_r46_c68 bl[68] br[68] wl[46] gnd reram_bitcell_7
Xbit_r47_c68 bl[68] br[68] wl[47] gnd reram_bitcell_7
Xbit_r48_c68 bl[68] br[68] wl[48] gnd reram_bitcell_7
Xbit_r49_c68 bl[68] br[68] wl[49] gnd reram_bitcell_7
Xbit_r50_c68 bl[68] br[68] wl[50] gnd reram_bitcell_7
Xbit_r51_c68 bl[68] br[68] wl[51] gnd reram_bitcell_7
Xbit_r52_c68 bl[68] br[68] wl[52] gnd reram_bitcell_7
Xbit_r53_c68 bl[68] br[68] wl[53] gnd reram_bitcell_7
Xbit_r54_c68 bl[68] br[68] wl[54] gnd reram_bitcell_7
Xbit_r55_c68 bl[68] br[68] wl[55] gnd reram_bitcell_7
Xbit_r56_c68 bl[68] br[68] wl[56] gnd reram_bitcell_7
Xbit_r57_c68 bl[68] br[68] wl[57] gnd reram_bitcell_7
Xbit_r58_c68 bl[68] br[68] wl[58] gnd reram_bitcell_7
Xbit_r59_c68 bl[68] br[68] wl[59] gnd reram_bitcell_7
Xbit_r60_c68 bl[68] br[68] wl[60] gnd reram_bitcell_7
Xbit_r61_c68 bl[68] br[68] wl[61] gnd reram_bitcell_7
Xbit_r62_c68 bl[68] br[68] wl[62] gnd reram_bitcell_7
Xbit_r63_c68 bl[68] br[68] wl[63] gnd reram_bitcell_7
Xbit_r0_c69 bl[69] br[69] wl[0] gnd reram_bitcell_7
Xbit_r1_c69 bl[69] br[69] wl[1] gnd reram_bitcell_7
Xbit_r2_c69 bl[69] br[69] wl[2] gnd reram_bitcell_7
Xbit_r3_c69 bl[69] br[69] wl[3] gnd reram_bitcell_7
Xbit_r4_c69 bl[69] br[69] wl[4] gnd reram_bitcell_7
Xbit_r5_c69 bl[69] br[69] wl[5] gnd reram_bitcell_7
Xbit_r6_c69 bl[69] br[69] wl[6] gnd reram_bitcell_7
Xbit_r7_c69 bl[69] br[69] wl[7] gnd reram_bitcell_7
Xbit_r8_c69 bl[69] br[69] wl[8] gnd reram_bitcell_7
Xbit_r9_c69 bl[69] br[69] wl[9] gnd reram_bitcell_7
Xbit_r10_c69 bl[69] br[69] wl[10] gnd reram_bitcell_7
Xbit_r11_c69 bl[69] br[69] wl[11] gnd reram_bitcell_7
Xbit_r12_c69 bl[69] br[69] wl[12] gnd reram_bitcell_7
Xbit_r13_c69 bl[69] br[69] wl[13] gnd reram_bitcell_7
Xbit_r14_c69 bl[69] br[69] wl[14] gnd reram_bitcell_7
Xbit_r15_c69 bl[69] br[69] wl[15] gnd reram_bitcell_7
Xbit_r16_c69 bl[69] br[69] wl[16] gnd reram_bitcell_7
Xbit_r17_c69 bl[69] br[69] wl[17] gnd reram_bitcell_7
Xbit_r18_c69 bl[69] br[69] wl[18] gnd reram_bitcell_7
Xbit_r19_c69 bl[69] br[69] wl[19] gnd reram_bitcell_7
Xbit_r20_c69 bl[69] br[69] wl[20] gnd reram_bitcell_7
Xbit_r21_c69 bl[69] br[69] wl[21] gnd reram_bitcell_7
Xbit_r22_c69 bl[69] br[69] wl[22] gnd reram_bitcell_7
Xbit_r23_c69 bl[69] br[69] wl[23] gnd reram_bitcell_7
Xbit_r24_c69 bl[69] br[69] wl[24] gnd reram_bitcell_7
Xbit_r25_c69 bl[69] br[69] wl[25] gnd reram_bitcell_7
Xbit_r26_c69 bl[69] br[69] wl[26] gnd reram_bitcell_7
Xbit_r27_c69 bl[69] br[69] wl[27] gnd reram_bitcell_7
Xbit_r28_c69 bl[69] br[69] wl[28] gnd reram_bitcell_7
Xbit_r29_c69 bl[69] br[69] wl[29] gnd reram_bitcell_7
Xbit_r30_c69 bl[69] br[69] wl[30] gnd reram_bitcell_7
Xbit_r31_c69 bl[69] br[69] wl[31] gnd reram_bitcell_7
Xbit_r32_c69 bl[69] br[69] wl[32] gnd reram_bitcell_7
Xbit_r33_c69 bl[69] br[69] wl[33] gnd reram_bitcell_7
Xbit_r34_c69 bl[69] br[69] wl[34] gnd reram_bitcell_7
Xbit_r35_c69 bl[69] br[69] wl[35] gnd reram_bitcell_7
Xbit_r36_c69 bl[69] br[69] wl[36] gnd reram_bitcell_7
Xbit_r37_c69 bl[69] br[69] wl[37] gnd reram_bitcell_7
Xbit_r38_c69 bl[69] br[69] wl[38] gnd reram_bitcell_7
Xbit_r39_c69 bl[69] br[69] wl[39] gnd reram_bitcell_7
Xbit_r40_c69 bl[69] br[69] wl[40] gnd reram_bitcell_7
Xbit_r41_c69 bl[69] br[69] wl[41] gnd reram_bitcell_7
Xbit_r42_c69 bl[69] br[69] wl[42] gnd reram_bitcell_7
Xbit_r43_c69 bl[69] br[69] wl[43] gnd reram_bitcell_7
Xbit_r44_c69 bl[69] br[69] wl[44] gnd reram_bitcell_7
Xbit_r45_c69 bl[69] br[69] wl[45] gnd reram_bitcell_7
Xbit_r46_c69 bl[69] br[69] wl[46] gnd reram_bitcell_7
Xbit_r47_c69 bl[69] br[69] wl[47] gnd reram_bitcell_7
Xbit_r48_c69 bl[69] br[69] wl[48] gnd reram_bitcell_7
Xbit_r49_c69 bl[69] br[69] wl[49] gnd reram_bitcell_7
Xbit_r50_c69 bl[69] br[69] wl[50] gnd reram_bitcell_7
Xbit_r51_c69 bl[69] br[69] wl[51] gnd reram_bitcell_7
Xbit_r52_c69 bl[69] br[69] wl[52] gnd reram_bitcell_7
Xbit_r53_c69 bl[69] br[69] wl[53] gnd reram_bitcell_7
Xbit_r54_c69 bl[69] br[69] wl[54] gnd reram_bitcell_7
Xbit_r55_c69 bl[69] br[69] wl[55] gnd reram_bitcell_7
Xbit_r56_c69 bl[69] br[69] wl[56] gnd reram_bitcell_7
Xbit_r57_c69 bl[69] br[69] wl[57] gnd reram_bitcell_7
Xbit_r58_c69 bl[69] br[69] wl[58] gnd reram_bitcell_7
Xbit_r59_c69 bl[69] br[69] wl[59] gnd reram_bitcell_7
Xbit_r60_c69 bl[69] br[69] wl[60] gnd reram_bitcell_7
Xbit_r61_c69 bl[69] br[69] wl[61] gnd reram_bitcell_7
Xbit_r62_c69 bl[69] br[69] wl[62] gnd reram_bitcell_7
Xbit_r63_c69 bl[69] br[69] wl[63] gnd reram_bitcell_7
Xbit_r0_c70 bl[70] br[70] wl[0] gnd reram_bitcell_7
Xbit_r1_c70 bl[70] br[70] wl[1] gnd reram_bitcell_7
Xbit_r2_c70 bl[70] br[70] wl[2] gnd reram_bitcell_7
Xbit_r3_c70 bl[70] br[70] wl[3] gnd reram_bitcell_7
Xbit_r4_c70 bl[70] br[70] wl[4] gnd reram_bitcell_7
Xbit_r5_c70 bl[70] br[70] wl[5] gnd reram_bitcell_7
Xbit_r6_c70 bl[70] br[70] wl[6] gnd reram_bitcell_7
Xbit_r7_c70 bl[70] br[70] wl[7] gnd reram_bitcell_7
Xbit_r8_c70 bl[70] br[70] wl[8] gnd reram_bitcell_7
Xbit_r9_c70 bl[70] br[70] wl[9] gnd reram_bitcell_7
Xbit_r10_c70 bl[70] br[70] wl[10] gnd reram_bitcell_7
Xbit_r11_c70 bl[70] br[70] wl[11] gnd reram_bitcell_7
Xbit_r12_c70 bl[70] br[70] wl[12] gnd reram_bitcell_7
Xbit_r13_c70 bl[70] br[70] wl[13] gnd reram_bitcell_7
Xbit_r14_c70 bl[70] br[70] wl[14] gnd reram_bitcell_7
Xbit_r15_c70 bl[70] br[70] wl[15] gnd reram_bitcell_7
Xbit_r16_c70 bl[70] br[70] wl[16] gnd reram_bitcell_7
Xbit_r17_c70 bl[70] br[70] wl[17] gnd reram_bitcell_7
Xbit_r18_c70 bl[70] br[70] wl[18] gnd reram_bitcell_7
Xbit_r19_c70 bl[70] br[70] wl[19] gnd reram_bitcell_7
Xbit_r20_c70 bl[70] br[70] wl[20] gnd reram_bitcell_7
Xbit_r21_c70 bl[70] br[70] wl[21] gnd reram_bitcell_7
Xbit_r22_c70 bl[70] br[70] wl[22] gnd reram_bitcell_7
Xbit_r23_c70 bl[70] br[70] wl[23] gnd reram_bitcell_7
Xbit_r24_c70 bl[70] br[70] wl[24] gnd reram_bitcell_7
Xbit_r25_c70 bl[70] br[70] wl[25] gnd reram_bitcell_7
Xbit_r26_c70 bl[70] br[70] wl[26] gnd reram_bitcell_7
Xbit_r27_c70 bl[70] br[70] wl[27] gnd reram_bitcell_7
Xbit_r28_c70 bl[70] br[70] wl[28] gnd reram_bitcell_7
Xbit_r29_c70 bl[70] br[70] wl[29] gnd reram_bitcell_7
Xbit_r30_c70 bl[70] br[70] wl[30] gnd reram_bitcell_7
Xbit_r31_c70 bl[70] br[70] wl[31] gnd reram_bitcell_7
Xbit_r32_c70 bl[70] br[70] wl[32] gnd reram_bitcell_7
Xbit_r33_c70 bl[70] br[70] wl[33] gnd reram_bitcell_7
Xbit_r34_c70 bl[70] br[70] wl[34] gnd reram_bitcell_7
Xbit_r35_c70 bl[70] br[70] wl[35] gnd reram_bitcell_7
Xbit_r36_c70 bl[70] br[70] wl[36] gnd reram_bitcell_7
Xbit_r37_c70 bl[70] br[70] wl[37] gnd reram_bitcell_7
Xbit_r38_c70 bl[70] br[70] wl[38] gnd reram_bitcell_7
Xbit_r39_c70 bl[70] br[70] wl[39] gnd reram_bitcell_7
Xbit_r40_c70 bl[70] br[70] wl[40] gnd reram_bitcell_7
Xbit_r41_c70 bl[70] br[70] wl[41] gnd reram_bitcell_7
Xbit_r42_c70 bl[70] br[70] wl[42] gnd reram_bitcell_7
Xbit_r43_c70 bl[70] br[70] wl[43] gnd reram_bitcell_7
Xbit_r44_c70 bl[70] br[70] wl[44] gnd reram_bitcell_7
Xbit_r45_c70 bl[70] br[70] wl[45] gnd reram_bitcell_7
Xbit_r46_c70 bl[70] br[70] wl[46] gnd reram_bitcell_7
Xbit_r47_c70 bl[70] br[70] wl[47] gnd reram_bitcell_7
Xbit_r48_c70 bl[70] br[70] wl[48] gnd reram_bitcell_7
Xbit_r49_c70 bl[70] br[70] wl[49] gnd reram_bitcell_7
Xbit_r50_c70 bl[70] br[70] wl[50] gnd reram_bitcell_7
Xbit_r51_c70 bl[70] br[70] wl[51] gnd reram_bitcell_7
Xbit_r52_c70 bl[70] br[70] wl[52] gnd reram_bitcell_7
Xbit_r53_c70 bl[70] br[70] wl[53] gnd reram_bitcell_7
Xbit_r54_c70 bl[70] br[70] wl[54] gnd reram_bitcell_7
Xbit_r55_c70 bl[70] br[70] wl[55] gnd reram_bitcell_7
Xbit_r56_c70 bl[70] br[70] wl[56] gnd reram_bitcell_7
Xbit_r57_c70 bl[70] br[70] wl[57] gnd reram_bitcell_7
Xbit_r58_c70 bl[70] br[70] wl[58] gnd reram_bitcell_7
Xbit_r59_c70 bl[70] br[70] wl[59] gnd reram_bitcell_7
Xbit_r60_c70 bl[70] br[70] wl[60] gnd reram_bitcell_7
Xbit_r61_c70 bl[70] br[70] wl[61] gnd reram_bitcell_7
Xbit_r62_c70 bl[70] br[70] wl[62] gnd reram_bitcell_7
Xbit_r63_c70 bl[70] br[70] wl[63] gnd reram_bitcell_7
Xbit_r0_c71 bl[71] br[71] wl[0] gnd reram_bitcell_7
Xbit_r1_c71 bl[71] br[71] wl[1] gnd reram_bitcell_7
Xbit_r2_c71 bl[71] br[71] wl[2] gnd reram_bitcell_7
Xbit_r3_c71 bl[71] br[71] wl[3] gnd reram_bitcell_7
Xbit_r4_c71 bl[71] br[71] wl[4] gnd reram_bitcell_7
Xbit_r5_c71 bl[71] br[71] wl[5] gnd reram_bitcell_7
Xbit_r6_c71 bl[71] br[71] wl[6] gnd reram_bitcell_7
Xbit_r7_c71 bl[71] br[71] wl[7] gnd reram_bitcell_7
Xbit_r8_c71 bl[71] br[71] wl[8] gnd reram_bitcell_7
Xbit_r9_c71 bl[71] br[71] wl[9] gnd reram_bitcell_7
Xbit_r10_c71 bl[71] br[71] wl[10] gnd reram_bitcell_7
Xbit_r11_c71 bl[71] br[71] wl[11] gnd reram_bitcell_7
Xbit_r12_c71 bl[71] br[71] wl[12] gnd reram_bitcell_7
Xbit_r13_c71 bl[71] br[71] wl[13] gnd reram_bitcell_7
Xbit_r14_c71 bl[71] br[71] wl[14] gnd reram_bitcell_7
Xbit_r15_c71 bl[71] br[71] wl[15] gnd reram_bitcell_7
Xbit_r16_c71 bl[71] br[71] wl[16] gnd reram_bitcell_7
Xbit_r17_c71 bl[71] br[71] wl[17] gnd reram_bitcell_7
Xbit_r18_c71 bl[71] br[71] wl[18] gnd reram_bitcell_7
Xbit_r19_c71 bl[71] br[71] wl[19] gnd reram_bitcell_7
Xbit_r20_c71 bl[71] br[71] wl[20] gnd reram_bitcell_7
Xbit_r21_c71 bl[71] br[71] wl[21] gnd reram_bitcell_7
Xbit_r22_c71 bl[71] br[71] wl[22] gnd reram_bitcell_7
Xbit_r23_c71 bl[71] br[71] wl[23] gnd reram_bitcell_7
Xbit_r24_c71 bl[71] br[71] wl[24] gnd reram_bitcell_7
Xbit_r25_c71 bl[71] br[71] wl[25] gnd reram_bitcell_7
Xbit_r26_c71 bl[71] br[71] wl[26] gnd reram_bitcell_7
Xbit_r27_c71 bl[71] br[71] wl[27] gnd reram_bitcell_7
Xbit_r28_c71 bl[71] br[71] wl[28] gnd reram_bitcell_7
Xbit_r29_c71 bl[71] br[71] wl[29] gnd reram_bitcell_7
Xbit_r30_c71 bl[71] br[71] wl[30] gnd reram_bitcell_7
Xbit_r31_c71 bl[71] br[71] wl[31] gnd reram_bitcell_7
Xbit_r32_c71 bl[71] br[71] wl[32] gnd reram_bitcell_7
Xbit_r33_c71 bl[71] br[71] wl[33] gnd reram_bitcell_7
Xbit_r34_c71 bl[71] br[71] wl[34] gnd reram_bitcell_7
Xbit_r35_c71 bl[71] br[71] wl[35] gnd reram_bitcell_7
Xbit_r36_c71 bl[71] br[71] wl[36] gnd reram_bitcell_7
Xbit_r37_c71 bl[71] br[71] wl[37] gnd reram_bitcell_7
Xbit_r38_c71 bl[71] br[71] wl[38] gnd reram_bitcell_7
Xbit_r39_c71 bl[71] br[71] wl[39] gnd reram_bitcell_7
Xbit_r40_c71 bl[71] br[71] wl[40] gnd reram_bitcell_7
Xbit_r41_c71 bl[71] br[71] wl[41] gnd reram_bitcell_7
Xbit_r42_c71 bl[71] br[71] wl[42] gnd reram_bitcell_7
Xbit_r43_c71 bl[71] br[71] wl[43] gnd reram_bitcell_7
Xbit_r44_c71 bl[71] br[71] wl[44] gnd reram_bitcell_7
Xbit_r45_c71 bl[71] br[71] wl[45] gnd reram_bitcell_7
Xbit_r46_c71 bl[71] br[71] wl[46] gnd reram_bitcell_7
Xbit_r47_c71 bl[71] br[71] wl[47] gnd reram_bitcell_7
Xbit_r48_c71 bl[71] br[71] wl[48] gnd reram_bitcell_7
Xbit_r49_c71 bl[71] br[71] wl[49] gnd reram_bitcell_7
Xbit_r50_c71 bl[71] br[71] wl[50] gnd reram_bitcell_7
Xbit_r51_c71 bl[71] br[71] wl[51] gnd reram_bitcell_7
Xbit_r52_c71 bl[71] br[71] wl[52] gnd reram_bitcell_7
Xbit_r53_c71 bl[71] br[71] wl[53] gnd reram_bitcell_7
Xbit_r54_c71 bl[71] br[71] wl[54] gnd reram_bitcell_7
Xbit_r55_c71 bl[71] br[71] wl[55] gnd reram_bitcell_7
Xbit_r56_c71 bl[71] br[71] wl[56] gnd reram_bitcell_7
Xbit_r57_c71 bl[71] br[71] wl[57] gnd reram_bitcell_7
Xbit_r58_c71 bl[71] br[71] wl[58] gnd reram_bitcell_7
Xbit_r59_c71 bl[71] br[71] wl[59] gnd reram_bitcell_7
Xbit_r60_c71 bl[71] br[71] wl[60] gnd reram_bitcell_7
Xbit_r61_c71 bl[71] br[71] wl[61] gnd reram_bitcell_7
Xbit_r62_c71 bl[71] br[71] wl[62] gnd reram_bitcell_7
Xbit_r63_c71 bl[71] br[71] wl[63] gnd reram_bitcell_7
Xbit_r0_c72 bl[72] br[72] wl[0] gnd reram_bitcell_7
Xbit_r1_c72 bl[72] br[72] wl[1] gnd reram_bitcell_7
Xbit_r2_c72 bl[72] br[72] wl[2] gnd reram_bitcell_7
Xbit_r3_c72 bl[72] br[72] wl[3] gnd reram_bitcell_7
Xbit_r4_c72 bl[72] br[72] wl[4] gnd reram_bitcell_7
Xbit_r5_c72 bl[72] br[72] wl[5] gnd reram_bitcell_7
Xbit_r6_c72 bl[72] br[72] wl[6] gnd reram_bitcell_7
Xbit_r7_c72 bl[72] br[72] wl[7] gnd reram_bitcell_7
Xbit_r8_c72 bl[72] br[72] wl[8] gnd reram_bitcell_7
Xbit_r9_c72 bl[72] br[72] wl[9] gnd reram_bitcell_7
Xbit_r10_c72 bl[72] br[72] wl[10] gnd reram_bitcell_7
Xbit_r11_c72 bl[72] br[72] wl[11] gnd reram_bitcell_7
Xbit_r12_c72 bl[72] br[72] wl[12] gnd reram_bitcell_7
Xbit_r13_c72 bl[72] br[72] wl[13] gnd reram_bitcell_7
Xbit_r14_c72 bl[72] br[72] wl[14] gnd reram_bitcell_7
Xbit_r15_c72 bl[72] br[72] wl[15] gnd reram_bitcell_7
Xbit_r16_c72 bl[72] br[72] wl[16] gnd reram_bitcell_7
Xbit_r17_c72 bl[72] br[72] wl[17] gnd reram_bitcell_7
Xbit_r18_c72 bl[72] br[72] wl[18] gnd reram_bitcell_7
Xbit_r19_c72 bl[72] br[72] wl[19] gnd reram_bitcell_7
Xbit_r20_c72 bl[72] br[72] wl[20] gnd reram_bitcell_7
Xbit_r21_c72 bl[72] br[72] wl[21] gnd reram_bitcell_7
Xbit_r22_c72 bl[72] br[72] wl[22] gnd reram_bitcell_7
Xbit_r23_c72 bl[72] br[72] wl[23] gnd reram_bitcell_7
Xbit_r24_c72 bl[72] br[72] wl[24] gnd reram_bitcell_7
Xbit_r25_c72 bl[72] br[72] wl[25] gnd reram_bitcell_7
Xbit_r26_c72 bl[72] br[72] wl[26] gnd reram_bitcell_7
Xbit_r27_c72 bl[72] br[72] wl[27] gnd reram_bitcell_7
Xbit_r28_c72 bl[72] br[72] wl[28] gnd reram_bitcell_7
Xbit_r29_c72 bl[72] br[72] wl[29] gnd reram_bitcell_7
Xbit_r30_c72 bl[72] br[72] wl[30] gnd reram_bitcell_7
Xbit_r31_c72 bl[72] br[72] wl[31] gnd reram_bitcell_7
Xbit_r32_c72 bl[72] br[72] wl[32] gnd reram_bitcell_7
Xbit_r33_c72 bl[72] br[72] wl[33] gnd reram_bitcell_7
Xbit_r34_c72 bl[72] br[72] wl[34] gnd reram_bitcell_7
Xbit_r35_c72 bl[72] br[72] wl[35] gnd reram_bitcell_7
Xbit_r36_c72 bl[72] br[72] wl[36] gnd reram_bitcell_7
Xbit_r37_c72 bl[72] br[72] wl[37] gnd reram_bitcell_7
Xbit_r38_c72 bl[72] br[72] wl[38] gnd reram_bitcell_7
Xbit_r39_c72 bl[72] br[72] wl[39] gnd reram_bitcell_7
Xbit_r40_c72 bl[72] br[72] wl[40] gnd reram_bitcell_7
Xbit_r41_c72 bl[72] br[72] wl[41] gnd reram_bitcell_7
Xbit_r42_c72 bl[72] br[72] wl[42] gnd reram_bitcell_7
Xbit_r43_c72 bl[72] br[72] wl[43] gnd reram_bitcell_7
Xbit_r44_c72 bl[72] br[72] wl[44] gnd reram_bitcell_7
Xbit_r45_c72 bl[72] br[72] wl[45] gnd reram_bitcell_7
Xbit_r46_c72 bl[72] br[72] wl[46] gnd reram_bitcell_7
Xbit_r47_c72 bl[72] br[72] wl[47] gnd reram_bitcell_7
Xbit_r48_c72 bl[72] br[72] wl[48] gnd reram_bitcell_7
Xbit_r49_c72 bl[72] br[72] wl[49] gnd reram_bitcell_7
Xbit_r50_c72 bl[72] br[72] wl[50] gnd reram_bitcell_7
Xbit_r51_c72 bl[72] br[72] wl[51] gnd reram_bitcell_7
Xbit_r52_c72 bl[72] br[72] wl[52] gnd reram_bitcell_7
Xbit_r53_c72 bl[72] br[72] wl[53] gnd reram_bitcell_7
Xbit_r54_c72 bl[72] br[72] wl[54] gnd reram_bitcell_7
Xbit_r55_c72 bl[72] br[72] wl[55] gnd reram_bitcell_7
Xbit_r56_c72 bl[72] br[72] wl[56] gnd reram_bitcell_7
Xbit_r57_c72 bl[72] br[72] wl[57] gnd reram_bitcell_7
Xbit_r58_c72 bl[72] br[72] wl[58] gnd reram_bitcell_7
Xbit_r59_c72 bl[72] br[72] wl[59] gnd reram_bitcell_7
Xbit_r60_c72 bl[72] br[72] wl[60] gnd reram_bitcell_7
Xbit_r61_c72 bl[72] br[72] wl[61] gnd reram_bitcell_7
Xbit_r62_c72 bl[72] br[72] wl[62] gnd reram_bitcell_7
Xbit_r63_c72 bl[72] br[72] wl[63] gnd reram_bitcell_7
Xbit_r0_c73 bl[73] br[73] wl[0] gnd reram_bitcell_7
Xbit_r1_c73 bl[73] br[73] wl[1] gnd reram_bitcell_7
Xbit_r2_c73 bl[73] br[73] wl[2] gnd reram_bitcell_7
Xbit_r3_c73 bl[73] br[73] wl[3] gnd reram_bitcell_7
Xbit_r4_c73 bl[73] br[73] wl[4] gnd reram_bitcell_7
Xbit_r5_c73 bl[73] br[73] wl[5] gnd reram_bitcell_7
Xbit_r6_c73 bl[73] br[73] wl[6] gnd reram_bitcell_7
Xbit_r7_c73 bl[73] br[73] wl[7] gnd reram_bitcell_7
Xbit_r8_c73 bl[73] br[73] wl[8] gnd reram_bitcell_7
Xbit_r9_c73 bl[73] br[73] wl[9] gnd reram_bitcell_7
Xbit_r10_c73 bl[73] br[73] wl[10] gnd reram_bitcell_7
Xbit_r11_c73 bl[73] br[73] wl[11] gnd reram_bitcell_7
Xbit_r12_c73 bl[73] br[73] wl[12] gnd reram_bitcell_7
Xbit_r13_c73 bl[73] br[73] wl[13] gnd reram_bitcell_7
Xbit_r14_c73 bl[73] br[73] wl[14] gnd reram_bitcell_7
Xbit_r15_c73 bl[73] br[73] wl[15] gnd reram_bitcell_7
Xbit_r16_c73 bl[73] br[73] wl[16] gnd reram_bitcell_7
Xbit_r17_c73 bl[73] br[73] wl[17] gnd reram_bitcell_7
Xbit_r18_c73 bl[73] br[73] wl[18] gnd reram_bitcell_7
Xbit_r19_c73 bl[73] br[73] wl[19] gnd reram_bitcell_7
Xbit_r20_c73 bl[73] br[73] wl[20] gnd reram_bitcell_7
Xbit_r21_c73 bl[73] br[73] wl[21] gnd reram_bitcell_7
Xbit_r22_c73 bl[73] br[73] wl[22] gnd reram_bitcell_7
Xbit_r23_c73 bl[73] br[73] wl[23] gnd reram_bitcell_7
Xbit_r24_c73 bl[73] br[73] wl[24] gnd reram_bitcell_7
Xbit_r25_c73 bl[73] br[73] wl[25] gnd reram_bitcell_7
Xbit_r26_c73 bl[73] br[73] wl[26] gnd reram_bitcell_7
Xbit_r27_c73 bl[73] br[73] wl[27] gnd reram_bitcell_7
Xbit_r28_c73 bl[73] br[73] wl[28] gnd reram_bitcell_7
Xbit_r29_c73 bl[73] br[73] wl[29] gnd reram_bitcell_7
Xbit_r30_c73 bl[73] br[73] wl[30] gnd reram_bitcell_7
Xbit_r31_c73 bl[73] br[73] wl[31] gnd reram_bitcell_7
Xbit_r32_c73 bl[73] br[73] wl[32] gnd reram_bitcell_7
Xbit_r33_c73 bl[73] br[73] wl[33] gnd reram_bitcell_7
Xbit_r34_c73 bl[73] br[73] wl[34] gnd reram_bitcell_7
Xbit_r35_c73 bl[73] br[73] wl[35] gnd reram_bitcell_7
Xbit_r36_c73 bl[73] br[73] wl[36] gnd reram_bitcell_7
Xbit_r37_c73 bl[73] br[73] wl[37] gnd reram_bitcell_7
Xbit_r38_c73 bl[73] br[73] wl[38] gnd reram_bitcell_7
Xbit_r39_c73 bl[73] br[73] wl[39] gnd reram_bitcell_7
Xbit_r40_c73 bl[73] br[73] wl[40] gnd reram_bitcell_7
Xbit_r41_c73 bl[73] br[73] wl[41] gnd reram_bitcell_7
Xbit_r42_c73 bl[73] br[73] wl[42] gnd reram_bitcell_7
Xbit_r43_c73 bl[73] br[73] wl[43] gnd reram_bitcell_7
Xbit_r44_c73 bl[73] br[73] wl[44] gnd reram_bitcell_7
Xbit_r45_c73 bl[73] br[73] wl[45] gnd reram_bitcell_7
Xbit_r46_c73 bl[73] br[73] wl[46] gnd reram_bitcell_7
Xbit_r47_c73 bl[73] br[73] wl[47] gnd reram_bitcell_7
Xbit_r48_c73 bl[73] br[73] wl[48] gnd reram_bitcell_7
Xbit_r49_c73 bl[73] br[73] wl[49] gnd reram_bitcell_7
Xbit_r50_c73 bl[73] br[73] wl[50] gnd reram_bitcell_7
Xbit_r51_c73 bl[73] br[73] wl[51] gnd reram_bitcell_7
Xbit_r52_c73 bl[73] br[73] wl[52] gnd reram_bitcell_7
Xbit_r53_c73 bl[73] br[73] wl[53] gnd reram_bitcell_7
Xbit_r54_c73 bl[73] br[73] wl[54] gnd reram_bitcell_7
Xbit_r55_c73 bl[73] br[73] wl[55] gnd reram_bitcell_7
Xbit_r56_c73 bl[73] br[73] wl[56] gnd reram_bitcell_7
Xbit_r57_c73 bl[73] br[73] wl[57] gnd reram_bitcell_7
Xbit_r58_c73 bl[73] br[73] wl[58] gnd reram_bitcell_7
Xbit_r59_c73 bl[73] br[73] wl[59] gnd reram_bitcell_7
Xbit_r60_c73 bl[73] br[73] wl[60] gnd reram_bitcell_7
Xbit_r61_c73 bl[73] br[73] wl[61] gnd reram_bitcell_7
Xbit_r62_c73 bl[73] br[73] wl[62] gnd reram_bitcell_7
Xbit_r63_c73 bl[73] br[73] wl[63] gnd reram_bitcell_7
Xbit_r0_c74 bl[74] br[74] wl[0] gnd reram_bitcell_7
Xbit_r1_c74 bl[74] br[74] wl[1] gnd reram_bitcell_7
Xbit_r2_c74 bl[74] br[74] wl[2] gnd reram_bitcell_7
Xbit_r3_c74 bl[74] br[74] wl[3] gnd reram_bitcell_7
Xbit_r4_c74 bl[74] br[74] wl[4] gnd reram_bitcell_7
Xbit_r5_c74 bl[74] br[74] wl[5] gnd reram_bitcell_7
Xbit_r6_c74 bl[74] br[74] wl[6] gnd reram_bitcell_7
Xbit_r7_c74 bl[74] br[74] wl[7] gnd reram_bitcell_7
Xbit_r8_c74 bl[74] br[74] wl[8] gnd reram_bitcell_7
Xbit_r9_c74 bl[74] br[74] wl[9] gnd reram_bitcell_7
Xbit_r10_c74 bl[74] br[74] wl[10] gnd reram_bitcell_7
Xbit_r11_c74 bl[74] br[74] wl[11] gnd reram_bitcell_7
Xbit_r12_c74 bl[74] br[74] wl[12] gnd reram_bitcell_7
Xbit_r13_c74 bl[74] br[74] wl[13] gnd reram_bitcell_7
Xbit_r14_c74 bl[74] br[74] wl[14] gnd reram_bitcell_7
Xbit_r15_c74 bl[74] br[74] wl[15] gnd reram_bitcell_7
Xbit_r16_c74 bl[74] br[74] wl[16] gnd reram_bitcell_7
Xbit_r17_c74 bl[74] br[74] wl[17] gnd reram_bitcell_7
Xbit_r18_c74 bl[74] br[74] wl[18] gnd reram_bitcell_7
Xbit_r19_c74 bl[74] br[74] wl[19] gnd reram_bitcell_7
Xbit_r20_c74 bl[74] br[74] wl[20] gnd reram_bitcell_7
Xbit_r21_c74 bl[74] br[74] wl[21] gnd reram_bitcell_7
Xbit_r22_c74 bl[74] br[74] wl[22] gnd reram_bitcell_7
Xbit_r23_c74 bl[74] br[74] wl[23] gnd reram_bitcell_7
Xbit_r24_c74 bl[74] br[74] wl[24] gnd reram_bitcell_7
Xbit_r25_c74 bl[74] br[74] wl[25] gnd reram_bitcell_7
Xbit_r26_c74 bl[74] br[74] wl[26] gnd reram_bitcell_7
Xbit_r27_c74 bl[74] br[74] wl[27] gnd reram_bitcell_7
Xbit_r28_c74 bl[74] br[74] wl[28] gnd reram_bitcell_7
Xbit_r29_c74 bl[74] br[74] wl[29] gnd reram_bitcell_7
Xbit_r30_c74 bl[74] br[74] wl[30] gnd reram_bitcell_7
Xbit_r31_c74 bl[74] br[74] wl[31] gnd reram_bitcell_7
Xbit_r32_c74 bl[74] br[74] wl[32] gnd reram_bitcell_7
Xbit_r33_c74 bl[74] br[74] wl[33] gnd reram_bitcell_7
Xbit_r34_c74 bl[74] br[74] wl[34] gnd reram_bitcell_7
Xbit_r35_c74 bl[74] br[74] wl[35] gnd reram_bitcell_7
Xbit_r36_c74 bl[74] br[74] wl[36] gnd reram_bitcell_7
Xbit_r37_c74 bl[74] br[74] wl[37] gnd reram_bitcell_7
Xbit_r38_c74 bl[74] br[74] wl[38] gnd reram_bitcell_7
Xbit_r39_c74 bl[74] br[74] wl[39] gnd reram_bitcell_7
Xbit_r40_c74 bl[74] br[74] wl[40] gnd reram_bitcell_7
Xbit_r41_c74 bl[74] br[74] wl[41] gnd reram_bitcell_7
Xbit_r42_c74 bl[74] br[74] wl[42] gnd reram_bitcell_7
Xbit_r43_c74 bl[74] br[74] wl[43] gnd reram_bitcell_7
Xbit_r44_c74 bl[74] br[74] wl[44] gnd reram_bitcell_7
Xbit_r45_c74 bl[74] br[74] wl[45] gnd reram_bitcell_7
Xbit_r46_c74 bl[74] br[74] wl[46] gnd reram_bitcell_7
Xbit_r47_c74 bl[74] br[74] wl[47] gnd reram_bitcell_7
Xbit_r48_c74 bl[74] br[74] wl[48] gnd reram_bitcell_7
Xbit_r49_c74 bl[74] br[74] wl[49] gnd reram_bitcell_7
Xbit_r50_c74 bl[74] br[74] wl[50] gnd reram_bitcell_7
Xbit_r51_c74 bl[74] br[74] wl[51] gnd reram_bitcell_7
Xbit_r52_c74 bl[74] br[74] wl[52] gnd reram_bitcell_7
Xbit_r53_c74 bl[74] br[74] wl[53] gnd reram_bitcell_7
Xbit_r54_c74 bl[74] br[74] wl[54] gnd reram_bitcell_7
Xbit_r55_c74 bl[74] br[74] wl[55] gnd reram_bitcell_7
Xbit_r56_c74 bl[74] br[74] wl[56] gnd reram_bitcell_7
Xbit_r57_c74 bl[74] br[74] wl[57] gnd reram_bitcell_7
Xbit_r58_c74 bl[74] br[74] wl[58] gnd reram_bitcell_7
Xbit_r59_c74 bl[74] br[74] wl[59] gnd reram_bitcell_7
Xbit_r60_c74 bl[74] br[74] wl[60] gnd reram_bitcell_7
Xbit_r61_c74 bl[74] br[74] wl[61] gnd reram_bitcell_7
Xbit_r62_c74 bl[74] br[74] wl[62] gnd reram_bitcell_7
Xbit_r63_c74 bl[74] br[74] wl[63] gnd reram_bitcell_7
Xbit_r0_c75 bl[75] br[75] wl[0] gnd reram_bitcell_7
Xbit_r1_c75 bl[75] br[75] wl[1] gnd reram_bitcell_7
Xbit_r2_c75 bl[75] br[75] wl[2] gnd reram_bitcell_7
Xbit_r3_c75 bl[75] br[75] wl[3] gnd reram_bitcell_7
Xbit_r4_c75 bl[75] br[75] wl[4] gnd reram_bitcell_7
Xbit_r5_c75 bl[75] br[75] wl[5] gnd reram_bitcell_7
Xbit_r6_c75 bl[75] br[75] wl[6] gnd reram_bitcell_7
Xbit_r7_c75 bl[75] br[75] wl[7] gnd reram_bitcell_7
Xbit_r8_c75 bl[75] br[75] wl[8] gnd reram_bitcell_7
Xbit_r9_c75 bl[75] br[75] wl[9] gnd reram_bitcell_7
Xbit_r10_c75 bl[75] br[75] wl[10] gnd reram_bitcell_7
Xbit_r11_c75 bl[75] br[75] wl[11] gnd reram_bitcell_7
Xbit_r12_c75 bl[75] br[75] wl[12] gnd reram_bitcell_7
Xbit_r13_c75 bl[75] br[75] wl[13] gnd reram_bitcell_7
Xbit_r14_c75 bl[75] br[75] wl[14] gnd reram_bitcell_7
Xbit_r15_c75 bl[75] br[75] wl[15] gnd reram_bitcell_7
Xbit_r16_c75 bl[75] br[75] wl[16] gnd reram_bitcell_7
Xbit_r17_c75 bl[75] br[75] wl[17] gnd reram_bitcell_7
Xbit_r18_c75 bl[75] br[75] wl[18] gnd reram_bitcell_7
Xbit_r19_c75 bl[75] br[75] wl[19] gnd reram_bitcell_7
Xbit_r20_c75 bl[75] br[75] wl[20] gnd reram_bitcell_7
Xbit_r21_c75 bl[75] br[75] wl[21] gnd reram_bitcell_7
Xbit_r22_c75 bl[75] br[75] wl[22] gnd reram_bitcell_7
Xbit_r23_c75 bl[75] br[75] wl[23] gnd reram_bitcell_7
Xbit_r24_c75 bl[75] br[75] wl[24] gnd reram_bitcell_7
Xbit_r25_c75 bl[75] br[75] wl[25] gnd reram_bitcell_7
Xbit_r26_c75 bl[75] br[75] wl[26] gnd reram_bitcell_7
Xbit_r27_c75 bl[75] br[75] wl[27] gnd reram_bitcell_7
Xbit_r28_c75 bl[75] br[75] wl[28] gnd reram_bitcell_7
Xbit_r29_c75 bl[75] br[75] wl[29] gnd reram_bitcell_7
Xbit_r30_c75 bl[75] br[75] wl[30] gnd reram_bitcell_7
Xbit_r31_c75 bl[75] br[75] wl[31] gnd reram_bitcell_7
Xbit_r32_c75 bl[75] br[75] wl[32] gnd reram_bitcell_7
Xbit_r33_c75 bl[75] br[75] wl[33] gnd reram_bitcell_7
Xbit_r34_c75 bl[75] br[75] wl[34] gnd reram_bitcell_7
Xbit_r35_c75 bl[75] br[75] wl[35] gnd reram_bitcell_7
Xbit_r36_c75 bl[75] br[75] wl[36] gnd reram_bitcell_7
Xbit_r37_c75 bl[75] br[75] wl[37] gnd reram_bitcell_7
Xbit_r38_c75 bl[75] br[75] wl[38] gnd reram_bitcell_7
Xbit_r39_c75 bl[75] br[75] wl[39] gnd reram_bitcell_7
Xbit_r40_c75 bl[75] br[75] wl[40] gnd reram_bitcell_7
Xbit_r41_c75 bl[75] br[75] wl[41] gnd reram_bitcell_7
Xbit_r42_c75 bl[75] br[75] wl[42] gnd reram_bitcell_7
Xbit_r43_c75 bl[75] br[75] wl[43] gnd reram_bitcell_7
Xbit_r44_c75 bl[75] br[75] wl[44] gnd reram_bitcell_7
Xbit_r45_c75 bl[75] br[75] wl[45] gnd reram_bitcell_7
Xbit_r46_c75 bl[75] br[75] wl[46] gnd reram_bitcell_7
Xbit_r47_c75 bl[75] br[75] wl[47] gnd reram_bitcell_7
Xbit_r48_c75 bl[75] br[75] wl[48] gnd reram_bitcell_7
Xbit_r49_c75 bl[75] br[75] wl[49] gnd reram_bitcell_7
Xbit_r50_c75 bl[75] br[75] wl[50] gnd reram_bitcell_7
Xbit_r51_c75 bl[75] br[75] wl[51] gnd reram_bitcell_7
Xbit_r52_c75 bl[75] br[75] wl[52] gnd reram_bitcell_7
Xbit_r53_c75 bl[75] br[75] wl[53] gnd reram_bitcell_7
Xbit_r54_c75 bl[75] br[75] wl[54] gnd reram_bitcell_7
Xbit_r55_c75 bl[75] br[75] wl[55] gnd reram_bitcell_7
Xbit_r56_c75 bl[75] br[75] wl[56] gnd reram_bitcell_7
Xbit_r57_c75 bl[75] br[75] wl[57] gnd reram_bitcell_7
Xbit_r58_c75 bl[75] br[75] wl[58] gnd reram_bitcell_7
Xbit_r59_c75 bl[75] br[75] wl[59] gnd reram_bitcell_7
Xbit_r60_c75 bl[75] br[75] wl[60] gnd reram_bitcell_7
Xbit_r61_c75 bl[75] br[75] wl[61] gnd reram_bitcell_7
Xbit_r62_c75 bl[75] br[75] wl[62] gnd reram_bitcell_7
Xbit_r63_c75 bl[75] br[75] wl[63] gnd reram_bitcell_7
Xbit_r0_c76 bl[76] br[76] wl[0] gnd reram_bitcell_7
Xbit_r1_c76 bl[76] br[76] wl[1] gnd reram_bitcell_7
Xbit_r2_c76 bl[76] br[76] wl[2] gnd reram_bitcell_7
Xbit_r3_c76 bl[76] br[76] wl[3] gnd reram_bitcell_7
Xbit_r4_c76 bl[76] br[76] wl[4] gnd reram_bitcell_7
Xbit_r5_c76 bl[76] br[76] wl[5] gnd reram_bitcell_7
Xbit_r6_c76 bl[76] br[76] wl[6] gnd reram_bitcell_7
Xbit_r7_c76 bl[76] br[76] wl[7] gnd reram_bitcell_7
Xbit_r8_c76 bl[76] br[76] wl[8] gnd reram_bitcell_7
Xbit_r9_c76 bl[76] br[76] wl[9] gnd reram_bitcell_7
Xbit_r10_c76 bl[76] br[76] wl[10] gnd reram_bitcell_7
Xbit_r11_c76 bl[76] br[76] wl[11] gnd reram_bitcell_7
Xbit_r12_c76 bl[76] br[76] wl[12] gnd reram_bitcell_7
Xbit_r13_c76 bl[76] br[76] wl[13] gnd reram_bitcell_7
Xbit_r14_c76 bl[76] br[76] wl[14] gnd reram_bitcell_7
Xbit_r15_c76 bl[76] br[76] wl[15] gnd reram_bitcell_7
Xbit_r16_c76 bl[76] br[76] wl[16] gnd reram_bitcell_7
Xbit_r17_c76 bl[76] br[76] wl[17] gnd reram_bitcell_7
Xbit_r18_c76 bl[76] br[76] wl[18] gnd reram_bitcell_7
Xbit_r19_c76 bl[76] br[76] wl[19] gnd reram_bitcell_7
Xbit_r20_c76 bl[76] br[76] wl[20] gnd reram_bitcell_7
Xbit_r21_c76 bl[76] br[76] wl[21] gnd reram_bitcell_7
Xbit_r22_c76 bl[76] br[76] wl[22] gnd reram_bitcell_7
Xbit_r23_c76 bl[76] br[76] wl[23] gnd reram_bitcell_7
Xbit_r24_c76 bl[76] br[76] wl[24] gnd reram_bitcell_7
Xbit_r25_c76 bl[76] br[76] wl[25] gnd reram_bitcell_7
Xbit_r26_c76 bl[76] br[76] wl[26] gnd reram_bitcell_7
Xbit_r27_c76 bl[76] br[76] wl[27] gnd reram_bitcell_7
Xbit_r28_c76 bl[76] br[76] wl[28] gnd reram_bitcell_7
Xbit_r29_c76 bl[76] br[76] wl[29] gnd reram_bitcell_7
Xbit_r30_c76 bl[76] br[76] wl[30] gnd reram_bitcell_7
Xbit_r31_c76 bl[76] br[76] wl[31] gnd reram_bitcell_7
Xbit_r32_c76 bl[76] br[76] wl[32] gnd reram_bitcell_7
Xbit_r33_c76 bl[76] br[76] wl[33] gnd reram_bitcell_7
Xbit_r34_c76 bl[76] br[76] wl[34] gnd reram_bitcell_7
Xbit_r35_c76 bl[76] br[76] wl[35] gnd reram_bitcell_7
Xbit_r36_c76 bl[76] br[76] wl[36] gnd reram_bitcell_7
Xbit_r37_c76 bl[76] br[76] wl[37] gnd reram_bitcell_7
Xbit_r38_c76 bl[76] br[76] wl[38] gnd reram_bitcell_7
Xbit_r39_c76 bl[76] br[76] wl[39] gnd reram_bitcell_7
Xbit_r40_c76 bl[76] br[76] wl[40] gnd reram_bitcell_7
Xbit_r41_c76 bl[76] br[76] wl[41] gnd reram_bitcell_7
Xbit_r42_c76 bl[76] br[76] wl[42] gnd reram_bitcell_7
Xbit_r43_c76 bl[76] br[76] wl[43] gnd reram_bitcell_7
Xbit_r44_c76 bl[76] br[76] wl[44] gnd reram_bitcell_7
Xbit_r45_c76 bl[76] br[76] wl[45] gnd reram_bitcell_7
Xbit_r46_c76 bl[76] br[76] wl[46] gnd reram_bitcell_7
Xbit_r47_c76 bl[76] br[76] wl[47] gnd reram_bitcell_7
Xbit_r48_c76 bl[76] br[76] wl[48] gnd reram_bitcell_7
Xbit_r49_c76 bl[76] br[76] wl[49] gnd reram_bitcell_7
Xbit_r50_c76 bl[76] br[76] wl[50] gnd reram_bitcell_7
Xbit_r51_c76 bl[76] br[76] wl[51] gnd reram_bitcell_7
Xbit_r52_c76 bl[76] br[76] wl[52] gnd reram_bitcell_7
Xbit_r53_c76 bl[76] br[76] wl[53] gnd reram_bitcell_7
Xbit_r54_c76 bl[76] br[76] wl[54] gnd reram_bitcell_7
Xbit_r55_c76 bl[76] br[76] wl[55] gnd reram_bitcell_7
Xbit_r56_c76 bl[76] br[76] wl[56] gnd reram_bitcell_7
Xbit_r57_c76 bl[76] br[76] wl[57] gnd reram_bitcell_7
Xbit_r58_c76 bl[76] br[76] wl[58] gnd reram_bitcell_7
Xbit_r59_c76 bl[76] br[76] wl[59] gnd reram_bitcell_7
Xbit_r60_c76 bl[76] br[76] wl[60] gnd reram_bitcell_7
Xbit_r61_c76 bl[76] br[76] wl[61] gnd reram_bitcell_7
Xbit_r62_c76 bl[76] br[76] wl[62] gnd reram_bitcell_7
Xbit_r63_c76 bl[76] br[76] wl[63] gnd reram_bitcell_7
Xbit_r0_c77 bl[77] br[77] wl[0] gnd reram_bitcell_7
Xbit_r1_c77 bl[77] br[77] wl[1] gnd reram_bitcell_7
Xbit_r2_c77 bl[77] br[77] wl[2] gnd reram_bitcell_7
Xbit_r3_c77 bl[77] br[77] wl[3] gnd reram_bitcell_7
Xbit_r4_c77 bl[77] br[77] wl[4] gnd reram_bitcell_7
Xbit_r5_c77 bl[77] br[77] wl[5] gnd reram_bitcell_7
Xbit_r6_c77 bl[77] br[77] wl[6] gnd reram_bitcell_7
Xbit_r7_c77 bl[77] br[77] wl[7] gnd reram_bitcell_7
Xbit_r8_c77 bl[77] br[77] wl[8] gnd reram_bitcell_7
Xbit_r9_c77 bl[77] br[77] wl[9] gnd reram_bitcell_7
Xbit_r10_c77 bl[77] br[77] wl[10] gnd reram_bitcell_7
Xbit_r11_c77 bl[77] br[77] wl[11] gnd reram_bitcell_7
Xbit_r12_c77 bl[77] br[77] wl[12] gnd reram_bitcell_7
Xbit_r13_c77 bl[77] br[77] wl[13] gnd reram_bitcell_7
Xbit_r14_c77 bl[77] br[77] wl[14] gnd reram_bitcell_7
Xbit_r15_c77 bl[77] br[77] wl[15] gnd reram_bitcell_7
Xbit_r16_c77 bl[77] br[77] wl[16] gnd reram_bitcell_7
Xbit_r17_c77 bl[77] br[77] wl[17] gnd reram_bitcell_7
Xbit_r18_c77 bl[77] br[77] wl[18] gnd reram_bitcell_7
Xbit_r19_c77 bl[77] br[77] wl[19] gnd reram_bitcell_7
Xbit_r20_c77 bl[77] br[77] wl[20] gnd reram_bitcell_7
Xbit_r21_c77 bl[77] br[77] wl[21] gnd reram_bitcell_7
Xbit_r22_c77 bl[77] br[77] wl[22] gnd reram_bitcell_7
Xbit_r23_c77 bl[77] br[77] wl[23] gnd reram_bitcell_7
Xbit_r24_c77 bl[77] br[77] wl[24] gnd reram_bitcell_7
Xbit_r25_c77 bl[77] br[77] wl[25] gnd reram_bitcell_7
Xbit_r26_c77 bl[77] br[77] wl[26] gnd reram_bitcell_7
Xbit_r27_c77 bl[77] br[77] wl[27] gnd reram_bitcell_7
Xbit_r28_c77 bl[77] br[77] wl[28] gnd reram_bitcell_7
Xbit_r29_c77 bl[77] br[77] wl[29] gnd reram_bitcell_7
Xbit_r30_c77 bl[77] br[77] wl[30] gnd reram_bitcell_7
Xbit_r31_c77 bl[77] br[77] wl[31] gnd reram_bitcell_7
Xbit_r32_c77 bl[77] br[77] wl[32] gnd reram_bitcell_7
Xbit_r33_c77 bl[77] br[77] wl[33] gnd reram_bitcell_7
Xbit_r34_c77 bl[77] br[77] wl[34] gnd reram_bitcell_7
Xbit_r35_c77 bl[77] br[77] wl[35] gnd reram_bitcell_7
Xbit_r36_c77 bl[77] br[77] wl[36] gnd reram_bitcell_7
Xbit_r37_c77 bl[77] br[77] wl[37] gnd reram_bitcell_7
Xbit_r38_c77 bl[77] br[77] wl[38] gnd reram_bitcell_7
Xbit_r39_c77 bl[77] br[77] wl[39] gnd reram_bitcell_7
Xbit_r40_c77 bl[77] br[77] wl[40] gnd reram_bitcell_7
Xbit_r41_c77 bl[77] br[77] wl[41] gnd reram_bitcell_7
Xbit_r42_c77 bl[77] br[77] wl[42] gnd reram_bitcell_7
Xbit_r43_c77 bl[77] br[77] wl[43] gnd reram_bitcell_7
Xbit_r44_c77 bl[77] br[77] wl[44] gnd reram_bitcell_7
Xbit_r45_c77 bl[77] br[77] wl[45] gnd reram_bitcell_7
Xbit_r46_c77 bl[77] br[77] wl[46] gnd reram_bitcell_7
Xbit_r47_c77 bl[77] br[77] wl[47] gnd reram_bitcell_7
Xbit_r48_c77 bl[77] br[77] wl[48] gnd reram_bitcell_7
Xbit_r49_c77 bl[77] br[77] wl[49] gnd reram_bitcell_7
Xbit_r50_c77 bl[77] br[77] wl[50] gnd reram_bitcell_7
Xbit_r51_c77 bl[77] br[77] wl[51] gnd reram_bitcell_7
Xbit_r52_c77 bl[77] br[77] wl[52] gnd reram_bitcell_7
Xbit_r53_c77 bl[77] br[77] wl[53] gnd reram_bitcell_7
Xbit_r54_c77 bl[77] br[77] wl[54] gnd reram_bitcell_7
Xbit_r55_c77 bl[77] br[77] wl[55] gnd reram_bitcell_7
Xbit_r56_c77 bl[77] br[77] wl[56] gnd reram_bitcell_7
Xbit_r57_c77 bl[77] br[77] wl[57] gnd reram_bitcell_7
Xbit_r58_c77 bl[77] br[77] wl[58] gnd reram_bitcell_7
Xbit_r59_c77 bl[77] br[77] wl[59] gnd reram_bitcell_7
Xbit_r60_c77 bl[77] br[77] wl[60] gnd reram_bitcell_7
Xbit_r61_c77 bl[77] br[77] wl[61] gnd reram_bitcell_7
Xbit_r62_c77 bl[77] br[77] wl[62] gnd reram_bitcell_7
Xbit_r63_c77 bl[77] br[77] wl[63] gnd reram_bitcell_7
Xbit_r0_c78 bl[78] br[78] wl[0] gnd reram_bitcell_7
Xbit_r1_c78 bl[78] br[78] wl[1] gnd reram_bitcell_7
Xbit_r2_c78 bl[78] br[78] wl[2] gnd reram_bitcell_7
Xbit_r3_c78 bl[78] br[78] wl[3] gnd reram_bitcell_7
Xbit_r4_c78 bl[78] br[78] wl[4] gnd reram_bitcell_7
Xbit_r5_c78 bl[78] br[78] wl[5] gnd reram_bitcell_7
Xbit_r6_c78 bl[78] br[78] wl[6] gnd reram_bitcell_7
Xbit_r7_c78 bl[78] br[78] wl[7] gnd reram_bitcell_7
Xbit_r8_c78 bl[78] br[78] wl[8] gnd reram_bitcell_7
Xbit_r9_c78 bl[78] br[78] wl[9] gnd reram_bitcell_7
Xbit_r10_c78 bl[78] br[78] wl[10] gnd reram_bitcell_7
Xbit_r11_c78 bl[78] br[78] wl[11] gnd reram_bitcell_7
Xbit_r12_c78 bl[78] br[78] wl[12] gnd reram_bitcell_7
Xbit_r13_c78 bl[78] br[78] wl[13] gnd reram_bitcell_7
Xbit_r14_c78 bl[78] br[78] wl[14] gnd reram_bitcell_7
Xbit_r15_c78 bl[78] br[78] wl[15] gnd reram_bitcell_7
Xbit_r16_c78 bl[78] br[78] wl[16] gnd reram_bitcell_7
Xbit_r17_c78 bl[78] br[78] wl[17] gnd reram_bitcell_7
Xbit_r18_c78 bl[78] br[78] wl[18] gnd reram_bitcell_7
Xbit_r19_c78 bl[78] br[78] wl[19] gnd reram_bitcell_7
Xbit_r20_c78 bl[78] br[78] wl[20] gnd reram_bitcell_7
Xbit_r21_c78 bl[78] br[78] wl[21] gnd reram_bitcell_7
Xbit_r22_c78 bl[78] br[78] wl[22] gnd reram_bitcell_7
Xbit_r23_c78 bl[78] br[78] wl[23] gnd reram_bitcell_7
Xbit_r24_c78 bl[78] br[78] wl[24] gnd reram_bitcell_7
Xbit_r25_c78 bl[78] br[78] wl[25] gnd reram_bitcell_7
Xbit_r26_c78 bl[78] br[78] wl[26] gnd reram_bitcell_7
Xbit_r27_c78 bl[78] br[78] wl[27] gnd reram_bitcell_7
Xbit_r28_c78 bl[78] br[78] wl[28] gnd reram_bitcell_7
Xbit_r29_c78 bl[78] br[78] wl[29] gnd reram_bitcell_7
Xbit_r30_c78 bl[78] br[78] wl[30] gnd reram_bitcell_7
Xbit_r31_c78 bl[78] br[78] wl[31] gnd reram_bitcell_7
Xbit_r32_c78 bl[78] br[78] wl[32] gnd reram_bitcell_7
Xbit_r33_c78 bl[78] br[78] wl[33] gnd reram_bitcell_7
Xbit_r34_c78 bl[78] br[78] wl[34] gnd reram_bitcell_7
Xbit_r35_c78 bl[78] br[78] wl[35] gnd reram_bitcell_7
Xbit_r36_c78 bl[78] br[78] wl[36] gnd reram_bitcell_7
Xbit_r37_c78 bl[78] br[78] wl[37] gnd reram_bitcell_7
Xbit_r38_c78 bl[78] br[78] wl[38] gnd reram_bitcell_7
Xbit_r39_c78 bl[78] br[78] wl[39] gnd reram_bitcell_7
Xbit_r40_c78 bl[78] br[78] wl[40] gnd reram_bitcell_7
Xbit_r41_c78 bl[78] br[78] wl[41] gnd reram_bitcell_7
Xbit_r42_c78 bl[78] br[78] wl[42] gnd reram_bitcell_7
Xbit_r43_c78 bl[78] br[78] wl[43] gnd reram_bitcell_7
Xbit_r44_c78 bl[78] br[78] wl[44] gnd reram_bitcell_7
Xbit_r45_c78 bl[78] br[78] wl[45] gnd reram_bitcell_7
Xbit_r46_c78 bl[78] br[78] wl[46] gnd reram_bitcell_7
Xbit_r47_c78 bl[78] br[78] wl[47] gnd reram_bitcell_7
Xbit_r48_c78 bl[78] br[78] wl[48] gnd reram_bitcell_7
Xbit_r49_c78 bl[78] br[78] wl[49] gnd reram_bitcell_7
Xbit_r50_c78 bl[78] br[78] wl[50] gnd reram_bitcell_7
Xbit_r51_c78 bl[78] br[78] wl[51] gnd reram_bitcell_7
Xbit_r52_c78 bl[78] br[78] wl[52] gnd reram_bitcell_7
Xbit_r53_c78 bl[78] br[78] wl[53] gnd reram_bitcell_7
Xbit_r54_c78 bl[78] br[78] wl[54] gnd reram_bitcell_7
Xbit_r55_c78 bl[78] br[78] wl[55] gnd reram_bitcell_7
Xbit_r56_c78 bl[78] br[78] wl[56] gnd reram_bitcell_7
Xbit_r57_c78 bl[78] br[78] wl[57] gnd reram_bitcell_7
Xbit_r58_c78 bl[78] br[78] wl[58] gnd reram_bitcell_7
Xbit_r59_c78 bl[78] br[78] wl[59] gnd reram_bitcell_7
Xbit_r60_c78 bl[78] br[78] wl[60] gnd reram_bitcell_7
Xbit_r61_c78 bl[78] br[78] wl[61] gnd reram_bitcell_7
Xbit_r62_c78 bl[78] br[78] wl[62] gnd reram_bitcell_7
Xbit_r63_c78 bl[78] br[78] wl[63] gnd reram_bitcell_7
Xbit_r0_c79 bl[79] br[79] wl[0] gnd reram_bitcell_7
Xbit_r1_c79 bl[79] br[79] wl[1] gnd reram_bitcell_7
Xbit_r2_c79 bl[79] br[79] wl[2] gnd reram_bitcell_7
Xbit_r3_c79 bl[79] br[79] wl[3] gnd reram_bitcell_7
Xbit_r4_c79 bl[79] br[79] wl[4] gnd reram_bitcell_7
Xbit_r5_c79 bl[79] br[79] wl[5] gnd reram_bitcell_7
Xbit_r6_c79 bl[79] br[79] wl[6] gnd reram_bitcell_7
Xbit_r7_c79 bl[79] br[79] wl[7] gnd reram_bitcell_7
Xbit_r8_c79 bl[79] br[79] wl[8] gnd reram_bitcell_7
Xbit_r9_c79 bl[79] br[79] wl[9] gnd reram_bitcell_7
Xbit_r10_c79 bl[79] br[79] wl[10] gnd reram_bitcell_7
Xbit_r11_c79 bl[79] br[79] wl[11] gnd reram_bitcell_7
Xbit_r12_c79 bl[79] br[79] wl[12] gnd reram_bitcell_7
Xbit_r13_c79 bl[79] br[79] wl[13] gnd reram_bitcell_7
Xbit_r14_c79 bl[79] br[79] wl[14] gnd reram_bitcell_7
Xbit_r15_c79 bl[79] br[79] wl[15] gnd reram_bitcell_7
Xbit_r16_c79 bl[79] br[79] wl[16] gnd reram_bitcell_7
Xbit_r17_c79 bl[79] br[79] wl[17] gnd reram_bitcell_7
Xbit_r18_c79 bl[79] br[79] wl[18] gnd reram_bitcell_7
Xbit_r19_c79 bl[79] br[79] wl[19] gnd reram_bitcell_7
Xbit_r20_c79 bl[79] br[79] wl[20] gnd reram_bitcell_7
Xbit_r21_c79 bl[79] br[79] wl[21] gnd reram_bitcell_7
Xbit_r22_c79 bl[79] br[79] wl[22] gnd reram_bitcell_7
Xbit_r23_c79 bl[79] br[79] wl[23] gnd reram_bitcell_7
Xbit_r24_c79 bl[79] br[79] wl[24] gnd reram_bitcell_7
Xbit_r25_c79 bl[79] br[79] wl[25] gnd reram_bitcell_7
Xbit_r26_c79 bl[79] br[79] wl[26] gnd reram_bitcell_7
Xbit_r27_c79 bl[79] br[79] wl[27] gnd reram_bitcell_7
Xbit_r28_c79 bl[79] br[79] wl[28] gnd reram_bitcell_7
Xbit_r29_c79 bl[79] br[79] wl[29] gnd reram_bitcell_7
Xbit_r30_c79 bl[79] br[79] wl[30] gnd reram_bitcell_7
Xbit_r31_c79 bl[79] br[79] wl[31] gnd reram_bitcell_7
Xbit_r32_c79 bl[79] br[79] wl[32] gnd reram_bitcell_7
Xbit_r33_c79 bl[79] br[79] wl[33] gnd reram_bitcell_7
Xbit_r34_c79 bl[79] br[79] wl[34] gnd reram_bitcell_7
Xbit_r35_c79 bl[79] br[79] wl[35] gnd reram_bitcell_7
Xbit_r36_c79 bl[79] br[79] wl[36] gnd reram_bitcell_7
Xbit_r37_c79 bl[79] br[79] wl[37] gnd reram_bitcell_7
Xbit_r38_c79 bl[79] br[79] wl[38] gnd reram_bitcell_7
Xbit_r39_c79 bl[79] br[79] wl[39] gnd reram_bitcell_7
Xbit_r40_c79 bl[79] br[79] wl[40] gnd reram_bitcell_7
Xbit_r41_c79 bl[79] br[79] wl[41] gnd reram_bitcell_7
Xbit_r42_c79 bl[79] br[79] wl[42] gnd reram_bitcell_7
Xbit_r43_c79 bl[79] br[79] wl[43] gnd reram_bitcell_7
Xbit_r44_c79 bl[79] br[79] wl[44] gnd reram_bitcell_7
Xbit_r45_c79 bl[79] br[79] wl[45] gnd reram_bitcell_7
Xbit_r46_c79 bl[79] br[79] wl[46] gnd reram_bitcell_7
Xbit_r47_c79 bl[79] br[79] wl[47] gnd reram_bitcell_7
Xbit_r48_c79 bl[79] br[79] wl[48] gnd reram_bitcell_7
Xbit_r49_c79 bl[79] br[79] wl[49] gnd reram_bitcell_7
Xbit_r50_c79 bl[79] br[79] wl[50] gnd reram_bitcell_7
Xbit_r51_c79 bl[79] br[79] wl[51] gnd reram_bitcell_7
Xbit_r52_c79 bl[79] br[79] wl[52] gnd reram_bitcell_7
Xbit_r53_c79 bl[79] br[79] wl[53] gnd reram_bitcell_7
Xbit_r54_c79 bl[79] br[79] wl[54] gnd reram_bitcell_7
Xbit_r55_c79 bl[79] br[79] wl[55] gnd reram_bitcell_7
Xbit_r56_c79 bl[79] br[79] wl[56] gnd reram_bitcell_7
Xbit_r57_c79 bl[79] br[79] wl[57] gnd reram_bitcell_7
Xbit_r58_c79 bl[79] br[79] wl[58] gnd reram_bitcell_7
Xbit_r59_c79 bl[79] br[79] wl[59] gnd reram_bitcell_7
Xbit_r60_c79 bl[79] br[79] wl[60] gnd reram_bitcell_7
Xbit_r61_c79 bl[79] br[79] wl[61] gnd reram_bitcell_7
Xbit_r62_c79 bl[79] br[79] wl[62] gnd reram_bitcell_7
Xbit_r63_c79 bl[79] br[79] wl[63] gnd reram_bitcell_7
Xbit_r0_c80 bl[80] br[80] wl[0] gnd reram_bitcell_7
Xbit_r1_c80 bl[80] br[80] wl[1] gnd reram_bitcell_7
Xbit_r2_c80 bl[80] br[80] wl[2] gnd reram_bitcell_7
Xbit_r3_c80 bl[80] br[80] wl[3] gnd reram_bitcell_7
Xbit_r4_c80 bl[80] br[80] wl[4] gnd reram_bitcell_7
Xbit_r5_c80 bl[80] br[80] wl[5] gnd reram_bitcell_7
Xbit_r6_c80 bl[80] br[80] wl[6] gnd reram_bitcell_7
Xbit_r7_c80 bl[80] br[80] wl[7] gnd reram_bitcell_7
Xbit_r8_c80 bl[80] br[80] wl[8] gnd reram_bitcell_7
Xbit_r9_c80 bl[80] br[80] wl[9] gnd reram_bitcell_7
Xbit_r10_c80 bl[80] br[80] wl[10] gnd reram_bitcell_7
Xbit_r11_c80 bl[80] br[80] wl[11] gnd reram_bitcell_7
Xbit_r12_c80 bl[80] br[80] wl[12] gnd reram_bitcell_7
Xbit_r13_c80 bl[80] br[80] wl[13] gnd reram_bitcell_7
Xbit_r14_c80 bl[80] br[80] wl[14] gnd reram_bitcell_7
Xbit_r15_c80 bl[80] br[80] wl[15] gnd reram_bitcell_7
Xbit_r16_c80 bl[80] br[80] wl[16] gnd reram_bitcell_7
Xbit_r17_c80 bl[80] br[80] wl[17] gnd reram_bitcell_7
Xbit_r18_c80 bl[80] br[80] wl[18] gnd reram_bitcell_7
Xbit_r19_c80 bl[80] br[80] wl[19] gnd reram_bitcell_7
Xbit_r20_c80 bl[80] br[80] wl[20] gnd reram_bitcell_7
Xbit_r21_c80 bl[80] br[80] wl[21] gnd reram_bitcell_7
Xbit_r22_c80 bl[80] br[80] wl[22] gnd reram_bitcell_7
Xbit_r23_c80 bl[80] br[80] wl[23] gnd reram_bitcell_7
Xbit_r24_c80 bl[80] br[80] wl[24] gnd reram_bitcell_7
Xbit_r25_c80 bl[80] br[80] wl[25] gnd reram_bitcell_7
Xbit_r26_c80 bl[80] br[80] wl[26] gnd reram_bitcell_7
Xbit_r27_c80 bl[80] br[80] wl[27] gnd reram_bitcell_7
Xbit_r28_c80 bl[80] br[80] wl[28] gnd reram_bitcell_7
Xbit_r29_c80 bl[80] br[80] wl[29] gnd reram_bitcell_7
Xbit_r30_c80 bl[80] br[80] wl[30] gnd reram_bitcell_7
Xbit_r31_c80 bl[80] br[80] wl[31] gnd reram_bitcell_7
Xbit_r32_c80 bl[80] br[80] wl[32] gnd reram_bitcell_7
Xbit_r33_c80 bl[80] br[80] wl[33] gnd reram_bitcell_7
Xbit_r34_c80 bl[80] br[80] wl[34] gnd reram_bitcell_7
Xbit_r35_c80 bl[80] br[80] wl[35] gnd reram_bitcell_7
Xbit_r36_c80 bl[80] br[80] wl[36] gnd reram_bitcell_7
Xbit_r37_c80 bl[80] br[80] wl[37] gnd reram_bitcell_7
Xbit_r38_c80 bl[80] br[80] wl[38] gnd reram_bitcell_7
Xbit_r39_c80 bl[80] br[80] wl[39] gnd reram_bitcell_7
Xbit_r40_c80 bl[80] br[80] wl[40] gnd reram_bitcell_7
Xbit_r41_c80 bl[80] br[80] wl[41] gnd reram_bitcell_7
Xbit_r42_c80 bl[80] br[80] wl[42] gnd reram_bitcell_7
Xbit_r43_c80 bl[80] br[80] wl[43] gnd reram_bitcell_7
Xbit_r44_c80 bl[80] br[80] wl[44] gnd reram_bitcell_7
Xbit_r45_c80 bl[80] br[80] wl[45] gnd reram_bitcell_7
Xbit_r46_c80 bl[80] br[80] wl[46] gnd reram_bitcell_7
Xbit_r47_c80 bl[80] br[80] wl[47] gnd reram_bitcell_7
Xbit_r48_c80 bl[80] br[80] wl[48] gnd reram_bitcell_7
Xbit_r49_c80 bl[80] br[80] wl[49] gnd reram_bitcell_7
Xbit_r50_c80 bl[80] br[80] wl[50] gnd reram_bitcell_7
Xbit_r51_c80 bl[80] br[80] wl[51] gnd reram_bitcell_7
Xbit_r52_c80 bl[80] br[80] wl[52] gnd reram_bitcell_7
Xbit_r53_c80 bl[80] br[80] wl[53] gnd reram_bitcell_7
Xbit_r54_c80 bl[80] br[80] wl[54] gnd reram_bitcell_7
Xbit_r55_c80 bl[80] br[80] wl[55] gnd reram_bitcell_7
Xbit_r56_c80 bl[80] br[80] wl[56] gnd reram_bitcell_7
Xbit_r57_c80 bl[80] br[80] wl[57] gnd reram_bitcell_7
Xbit_r58_c80 bl[80] br[80] wl[58] gnd reram_bitcell_7
Xbit_r59_c80 bl[80] br[80] wl[59] gnd reram_bitcell_7
Xbit_r60_c80 bl[80] br[80] wl[60] gnd reram_bitcell_7
Xbit_r61_c80 bl[80] br[80] wl[61] gnd reram_bitcell_7
Xbit_r62_c80 bl[80] br[80] wl[62] gnd reram_bitcell_7
Xbit_r63_c80 bl[80] br[80] wl[63] gnd reram_bitcell_7
Xbit_r0_c81 bl[81] br[81] wl[0] gnd reram_bitcell_7
Xbit_r1_c81 bl[81] br[81] wl[1] gnd reram_bitcell_7
Xbit_r2_c81 bl[81] br[81] wl[2] gnd reram_bitcell_7
Xbit_r3_c81 bl[81] br[81] wl[3] gnd reram_bitcell_7
Xbit_r4_c81 bl[81] br[81] wl[4] gnd reram_bitcell_7
Xbit_r5_c81 bl[81] br[81] wl[5] gnd reram_bitcell_7
Xbit_r6_c81 bl[81] br[81] wl[6] gnd reram_bitcell_7
Xbit_r7_c81 bl[81] br[81] wl[7] gnd reram_bitcell_7
Xbit_r8_c81 bl[81] br[81] wl[8] gnd reram_bitcell_7
Xbit_r9_c81 bl[81] br[81] wl[9] gnd reram_bitcell_7
Xbit_r10_c81 bl[81] br[81] wl[10] gnd reram_bitcell_7
Xbit_r11_c81 bl[81] br[81] wl[11] gnd reram_bitcell_7
Xbit_r12_c81 bl[81] br[81] wl[12] gnd reram_bitcell_7
Xbit_r13_c81 bl[81] br[81] wl[13] gnd reram_bitcell_7
Xbit_r14_c81 bl[81] br[81] wl[14] gnd reram_bitcell_7
Xbit_r15_c81 bl[81] br[81] wl[15] gnd reram_bitcell_7
Xbit_r16_c81 bl[81] br[81] wl[16] gnd reram_bitcell_7
Xbit_r17_c81 bl[81] br[81] wl[17] gnd reram_bitcell_7
Xbit_r18_c81 bl[81] br[81] wl[18] gnd reram_bitcell_7
Xbit_r19_c81 bl[81] br[81] wl[19] gnd reram_bitcell_7
Xbit_r20_c81 bl[81] br[81] wl[20] gnd reram_bitcell_7
Xbit_r21_c81 bl[81] br[81] wl[21] gnd reram_bitcell_7
Xbit_r22_c81 bl[81] br[81] wl[22] gnd reram_bitcell_7
Xbit_r23_c81 bl[81] br[81] wl[23] gnd reram_bitcell_7
Xbit_r24_c81 bl[81] br[81] wl[24] gnd reram_bitcell_7
Xbit_r25_c81 bl[81] br[81] wl[25] gnd reram_bitcell_7
Xbit_r26_c81 bl[81] br[81] wl[26] gnd reram_bitcell_7
Xbit_r27_c81 bl[81] br[81] wl[27] gnd reram_bitcell_7
Xbit_r28_c81 bl[81] br[81] wl[28] gnd reram_bitcell_7
Xbit_r29_c81 bl[81] br[81] wl[29] gnd reram_bitcell_7
Xbit_r30_c81 bl[81] br[81] wl[30] gnd reram_bitcell_7
Xbit_r31_c81 bl[81] br[81] wl[31] gnd reram_bitcell_7
Xbit_r32_c81 bl[81] br[81] wl[32] gnd reram_bitcell_7
Xbit_r33_c81 bl[81] br[81] wl[33] gnd reram_bitcell_7
Xbit_r34_c81 bl[81] br[81] wl[34] gnd reram_bitcell_7
Xbit_r35_c81 bl[81] br[81] wl[35] gnd reram_bitcell_7
Xbit_r36_c81 bl[81] br[81] wl[36] gnd reram_bitcell_7
Xbit_r37_c81 bl[81] br[81] wl[37] gnd reram_bitcell_7
Xbit_r38_c81 bl[81] br[81] wl[38] gnd reram_bitcell_7
Xbit_r39_c81 bl[81] br[81] wl[39] gnd reram_bitcell_7
Xbit_r40_c81 bl[81] br[81] wl[40] gnd reram_bitcell_7
Xbit_r41_c81 bl[81] br[81] wl[41] gnd reram_bitcell_7
Xbit_r42_c81 bl[81] br[81] wl[42] gnd reram_bitcell_7
Xbit_r43_c81 bl[81] br[81] wl[43] gnd reram_bitcell_7
Xbit_r44_c81 bl[81] br[81] wl[44] gnd reram_bitcell_7
Xbit_r45_c81 bl[81] br[81] wl[45] gnd reram_bitcell_7
Xbit_r46_c81 bl[81] br[81] wl[46] gnd reram_bitcell_7
Xbit_r47_c81 bl[81] br[81] wl[47] gnd reram_bitcell_7
Xbit_r48_c81 bl[81] br[81] wl[48] gnd reram_bitcell_7
Xbit_r49_c81 bl[81] br[81] wl[49] gnd reram_bitcell_7
Xbit_r50_c81 bl[81] br[81] wl[50] gnd reram_bitcell_7
Xbit_r51_c81 bl[81] br[81] wl[51] gnd reram_bitcell_7
Xbit_r52_c81 bl[81] br[81] wl[52] gnd reram_bitcell_7
Xbit_r53_c81 bl[81] br[81] wl[53] gnd reram_bitcell_7
Xbit_r54_c81 bl[81] br[81] wl[54] gnd reram_bitcell_7
Xbit_r55_c81 bl[81] br[81] wl[55] gnd reram_bitcell_7
Xbit_r56_c81 bl[81] br[81] wl[56] gnd reram_bitcell_7
Xbit_r57_c81 bl[81] br[81] wl[57] gnd reram_bitcell_7
Xbit_r58_c81 bl[81] br[81] wl[58] gnd reram_bitcell_7
Xbit_r59_c81 bl[81] br[81] wl[59] gnd reram_bitcell_7
Xbit_r60_c81 bl[81] br[81] wl[60] gnd reram_bitcell_7
Xbit_r61_c81 bl[81] br[81] wl[61] gnd reram_bitcell_7
Xbit_r62_c81 bl[81] br[81] wl[62] gnd reram_bitcell_7
Xbit_r63_c81 bl[81] br[81] wl[63] gnd reram_bitcell_7
Xbit_r0_c82 bl[82] br[82] wl[0] gnd reram_bitcell_7
Xbit_r1_c82 bl[82] br[82] wl[1] gnd reram_bitcell_7
Xbit_r2_c82 bl[82] br[82] wl[2] gnd reram_bitcell_7
Xbit_r3_c82 bl[82] br[82] wl[3] gnd reram_bitcell_7
Xbit_r4_c82 bl[82] br[82] wl[4] gnd reram_bitcell_7
Xbit_r5_c82 bl[82] br[82] wl[5] gnd reram_bitcell_7
Xbit_r6_c82 bl[82] br[82] wl[6] gnd reram_bitcell_7
Xbit_r7_c82 bl[82] br[82] wl[7] gnd reram_bitcell_7
Xbit_r8_c82 bl[82] br[82] wl[8] gnd reram_bitcell_7
Xbit_r9_c82 bl[82] br[82] wl[9] gnd reram_bitcell_7
Xbit_r10_c82 bl[82] br[82] wl[10] gnd reram_bitcell_7
Xbit_r11_c82 bl[82] br[82] wl[11] gnd reram_bitcell_7
Xbit_r12_c82 bl[82] br[82] wl[12] gnd reram_bitcell_7
Xbit_r13_c82 bl[82] br[82] wl[13] gnd reram_bitcell_7
Xbit_r14_c82 bl[82] br[82] wl[14] gnd reram_bitcell_7
Xbit_r15_c82 bl[82] br[82] wl[15] gnd reram_bitcell_7
Xbit_r16_c82 bl[82] br[82] wl[16] gnd reram_bitcell_7
Xbit_r17_c82 bl[82] br[82] wl[17] gnd reram_bitcell_7
Xbit_r18_c82 bl[82] br[82] wl[18] gnd reram_bitcell_7
Xbit_r19_c82 bl[82] br[82] wl[19] gnd reram_bitcell_7
Xbit_r20_c82 bl[82] br[82] wl[20] gnd reram_bitcell_7
Xbit_r21_c82 bl[82] br[82] wl[21] gnd reram_bitcell_7
Xbit_r22_c82 bl[82] br[82] wl[22] gnd reram_bitcell_7
Xbit_r23_c82 bl[82] br[82] wl[23] gnd reram_bitcell_7
Xbit_r24_c82 bl[82] br[82] wl[24] gnd reram_bitcell_7
Xbit_r25_c82 bl[82] br[82] wl[25] gnd reram_bitcell_7
Xbit_r26_c82 bl[82] br[82] wl[26] gnd reram_bitcell_7
Xbit_r27_c82 bl[82] br[82] wl[27] gnd reram_bitcell_7
Xbit_r28_c82 bl[82] br[82] wl[28] gnd reram_bitcell_7
Xbit_r29_c82 bl[82] br[82] wl[29] gnd reram_bitcell_7
Xbit_r30_c82 bl[82] br[82] wl[30] gnd reram_bitcell_7
Xbit_r31_c82 bl[82] br[82] wl[31] gnd reram_bitcell_7
Xbit_r32_c82 bl[82] br[82] wl[32] gnd reram_bitcell_7
Xbit_r33_c82 bl[82] br[82] wl[33] gnd reram_bitcell_7
Xbit_r34_c82 bl[82] br[82] wl[34] gnd reram_bitcell_7
Xbit_r35_c82 bl[82] br[82] wl[35] gnd reram_bitcell_7
Xbit_r36_c82 bl[82] br[82] wl[36] gnd reram_bitcell_7
Xbit_r37_c82 bl[82] br[82] wl[37] gnd reram_bitcell_7
Xbit_r38_c82 bl[82] br[82] wl[38] gnd reram_bitcell_7
Xbit_r39_c82 bl[82] br[82] wl[39] gnd reram_bitcell_7
Xbit_r40_c82 bl[82] br[82] wl[40] gnd reram_bitcell_7
Xbit_r41_c82 bl[82] br[82] wl[41] gnd reram_bitcell_7
Xbit_r42_c82 bl[82] br[82] wl[42] gnd reram_bitcell_7
Xbit_r43_c82 bl[82] br[82] wl[43] gnd reram_bitcell_7
Xbit_r44_c82 bl[82] br[82] wl[44] gnd reram_bitcell_7
Xbit_r45_c82 bl[82] br[82] wl[45] gnd reram_bitcell_7
Xbit_r46_c82 bl[82] br[82] wl[46] gnd reram_bitcell_7
Xbit_r47_c82 bl[82] br[82] wl[47] gnd reram_bitcell_7
Xbit_r48_c82 bl[82] br[82] wl[48] gnd reram_bitcell_7
Xbit_r49_c82 bl[82] br[82] wl[49] gnd reram_bitcell_7
Xbit_r50_c82 bl[82] br[82] wl[50] gnd reram_bitcell_7
Xbit_r51_c82 bl[82] br[82] wl[51] gnd reram_bitcell_7
Xbit_r52_c82 bl[82] br[82] wl[52] gnd reram_bitcell_7
Xbit_r53_c82 bl[82] br[82] wl[53] gnd reram_bitcell_7
Xbit_r54_c82 bl[82] br[82] wl[54] gnd reram_bitcell_7
Xbit_r55_c82 bl[82] br[82] wl[55] gnd reram_bitcell_7
Xbit_r56_c82 bl[82] br[82] wl[56] gnd reram_bitcell_7
Xbit_r57_c82 bl[82] br[82] wl[57] gnd reram_bitcell_7
Xbit_r58_c82 bl[82] br[82] wl[58] gnd reram_bitcell_7
Xbit_r59_c82 bl[82] br[82] wl[59] gnd reram_bitcell_7
Xbit_r60_c82 bl[82] br[82] wl[60] gnd reram_bitcell_7
Xbit_r61_c82 bl[82] br[82] wl[61] gnd reram_bitcell_7
Xbit_r62_c82 bl[82] br[82] wl[62] gnd reram_bitcell_7
Xbit_r63_c82 bl[82] br[82] wl[63] gnd reram_bitcell_7
Xbit_r0_c83 bl[83] br[83] wl[0] gnd reram_bitcell_7
Xbit_r1_c83 bl[83] br[83] wl[1] gnd reram_bitcell_7
Xbit_r2_c83 bl[83] br[83] wl[2] gnd reram_bitcell_7
Xbit_r3_c83 bl[83] br[83] wl[3] gnd reram_bitcell_7
Xbit_r4_c83 bl[83] br[83] wl[4] gnd reram_bitcell_7
Xbit_r5_c83 bl[83] br[83] wl[5] gnd reram_bitcell_7
Xbit_r6_c83 bl[83] br[83] wl[6] gnd reram_bitcell_7
Xbit_r7_c83 bl[83] br[83] wl[7] gnd reram_bitcell_7
Xbit_r8_c83 bl[83] br[83] wl[8] gnd reram_bitcell_7
Xbit_r9_c83 bl[83] br[83] wl[9] gnd reram_bitcell_7
Xbit_r10_c83 bl[83] br[83] wl[10] gnd reram_bitcell_7
Xbit_r11_c83 bl[83] br[83] wl[11] gnd reram_bitcell_7
Xbit_r12_c83 bl[83] br[83] wl[12] gnd reram_bitcell_7
Xbit_r13_c83 bl[83] br[83] wl[13] gnd reram_bitcell_7
Xbit_r14_c83 bl[83] br[83] wl[14] gnd reram_bitcell_7
Xbit_r15_c83 bl[83] br[83] wl[15] gnd reram_bitcell_7
Xbit_r16_c83 bl[83] br[83] wl[16] gnd reram_bitcell_7
Xbit_r17_c83 bl[83] br[83] wl[17] gnd reram_bitcell_7
Xbit_r18_c83 bl[83] br[83] wl[18] gnd reram_bitcell_7
Xbit_r19_c83 bl[83] br[83] wl[19] gnd reram_bitcell_7
Xbit_r20_c83 bl[83] br[83] wl[20] gnd reram_bitcell_7
Xbit_r21_c83 bl[83] br[83] wl[21] gnd reram_bitcell_7
Xbit_r22_c83 bl[83] br[83] wl[22] gnd reram_bitcell_7
Xbit_r23_c83 bl[83] br[83] wl[23] gnd reram_bitcell_7
Xbit_r24_c83 bl[83] br[83] wl[24] gnd reram_bitcell_7
Xbit_r25_c83 bl[83] br[83] wl[25] gnd reram_bitcell_7
Xbit_r26_c83 bl[83] br[83] wl[26] gnd reram_bitcell_7
Xbit_r27_c83 bl[83] br[83] wl[27] gnd reram_bitcell_7
Xbit_r28_c83 bl[83] br[83] wl[28] gnd reram_bitcell_7
Xbit_r29_c83 bl[83] br[83] wl[29] gnd reram_bitcell_7
Xbit_r30_c83 bl[83] br[83] wl[30] gnd reram_bitcell_7
Xbit_r31_c83 bl[83] br[83] wl[31] gnd reram_bitcell_7
Xbit_r32_c83 bl[83] br[83] wl[32] gnd reram_bitcell_7
Xbit_r33_c83 bl[83] br[83] wl[33] gnd reram_bitcell_7
Xbit_r34_c83 bl[83] br[83] wl[34] gnd reram_bitcell_7
Xbit_r35_c83 bl[83] br[83] wl[35] gnd reram_bitcell_7
Xbit_r36_c83 bl[83] br[83] wl[36] gnd reram_bitcell_7
Xbit_r37_c83 bl[83] br[83] wl[37] gnd reram_bitcell_7
Xbit_r38_c83 bl[83] br[83] wl[38] gnd reram_bitcell_7
Xbit_r39_c83 bl[83] br[83] wl[39] gnd reram_bitcell_7
Xbit_r40_c83 bl[83] br[83] wl[40] gnd reram_bitcell_7
Xbit_r41_c83 bl[83] br[83] wl[41] gnd reram_bitcell_7
Xbit_r42_c83 bl[83] br[83] wl[42] gnd reram_bitcell_7
Xbit_r43_c83 bl[83] br[83] wl[43] gnd reram_bitcell_7
Xbit_r44_c83 bl[83] br[83] wl[44] gnd reram_bitcell_7
Xbit_r45_c83 bl[83] br[83] wl[45] gnd reram_bitcell_7
Xbit_r46_c83 bl[83] br[83] wl[46] gnd reram_bitcell_7
Xbit_r47_c83 bl[83] br[83] wl[47] gnd reram_bitcell_7
Xbit_r48_c83 bl[83] br[83] wl[48] gnd reram_bitcell_7
Xbit_r49_c83 bl[83] br[83] wl[49] gnd reram_bitcell_7
Xbit_r50_c83 bl[83] br[83] wl[50] gnd reram_bitcell_7
Xbit_r51_c83 bl[83] br[83] wl[51] gnd reram_bitcell_7
Xbit_r52_c83 bl[83] br[83] wl[52] gnd reram_bitcell_7
Xbit_r53_c83 bl[83] br[83] wl[53] gnd reram_bitcell_7
Xbit_r54_c83 bl[83] br[83] wl[54] gnd reram_bitcell_7
Xbit_r55_c83 bl[83] br[83] wl[55] gnd reram_bitcell_7
Xbit_r56_c83 bl[83] br[83] wl[56] gnd reram_bitcell_7
Xbit_r57_c83 bl[83] br[83] wl[57] gnd reram_bitcell_7
Xbit_r58_c83 bl[83] br[83] wl[58] gnd reram_bitcell_7
Xbit_r59_c83 bl[83] br[83] wl[59] gnd reram_bitcell_7
Xbit_r60_c83 bl[83] br[83] wl[60] gnd reram_bitcell_7
Xbit_r61_c83 bl[83] br[83] wl[61] gnd reram_bitcell_7
Xbit_r62_c83 bl[83] br[83] wl[62] gnd reram_bitcell_7
Xbit_r63_c83 bl[83] br[83] wl[63] gnd reram_bitcell_7
Xbit_r0_c84 bl[84] br[84] wl[0] gnd reram_bitcell_7
Xbit_r1_c84 bl[84] br[84] wl[1] gnd reram_bitcell_7
Xbit_r2_c84 bl[84] br[84] wl[2] gnd reram_bitcell_7
Xbit_r3_c84 bl[84] br[84] wl[3] gnd reram_bitcell_7
Xbit_r4_c84 bl[84] br[84] wl[4] gnd reram_bitcell_7
Xbit_r5_c84 bl[84] br[84] wl[5] gnd reram_bitcell_7
Xbit_r6_c84 bl[84] br[84] wl[6] gnd reram_bitcell_7
Xbit_r7_c84 bl[84] br[84] wl[7] gnd reram_bitcell_7
Xbit_r8_c84 bl[84] br[84] wl[8] gnd reram_bitcell_7
Xbit_r9_c84 bl[84] br[84] wl[9] gnd reram_bitcell_7
Xbit_r10_c84 bl[84] br[84] wl[10] gnd reram_bitcell_7
Xbit_r11_c84 bl[84] br[84] wl[11] gnd reram_bitcell_7
Xbit_r12_c84 bl[84] br[84] wl[12] gnd reram_bitcell_7
Xbit_r13_c84 bl[84] br[84] wl[13] gnd reram_bitcell_7
Xbit_r14_c84 bl[84] br[84] wl[14] gnd reram_bitcell_7
Xbit_r15_c84 bl[84] br[84] wl[15] gnd reram_bitcell_7
Xbit_r16_c84 bl[84] br[84] wl[16] gnd reram_bitcell_7
Xbit_r17_c84 bl[84] br[84] wl[17] gnd reram_bitcell_7
Xbit_r18_c84 bl[84] br[84] wl[18] gnd reram_bitcell_7
Xbit_r19_c84 bl[84] br[84] wl[19] gnd reram_bitcell_7
Xbit_r20_c84 bl[84] br[84] wl[20] gnd reram_bitcell_7
Xbit_r21_c84 bl[84] br[84] wl[21] gnd reram_bitcell_7
Xbit_r22_c84 bl[84] br[84] wl[22] gnd reram_bitcell_7
Xbit_r23_c84 bl[84] br[84] wl[23] gnd reram_bitcell_7
Xbit_r24_c84 bl[84] br[84] wl[24] gnd reram_bitcell_7
Xbit_r25_c84 bl[84] br[84] wl[25] gnd reram_bitcell_7
Xbit_r26_c84 bl[84] br[84] wl[26] gnd reram_bitcell_7
Xbit_r27_c84 bl[84] br[84] wl[27] gnd reram_bitcell_7
Xbit_r28_c84 bl[84] br[84] wl[28] gnd reram_bitcell_7
Xbit_r29_c84 bl[84] br[84] wl[29] gnd reram_bitcell_7
Xbit_r30_c84 bl[84] br[84] wl[30] gnd reram_bitcell_7
Xbit_r31_c84 bl[84] br[84] wl[31] gnd reram_bitcell_7
Xbit_r32_c84 bl[84] br[84] wl[32] gnd reram_bitcell_7
Xbit_r33_c84 bl[84] br[84] wl[33] gnd reram_bitcell_7
Xbit_r34_c84 bl[84] br[84] wl[34] gnd reram_bitcell_7
Xbit_r35_c84 bl[84] br[84] wl[35] gnd reram_bitcell_7
Xbit_r36_c84 bl[84] br[84] wl[36] gnd reram_bitcell_7
Xbit_r37_c84 bl[84] br[84] wl[37] gnd reram_bitcell_7
Xbit_r38_c84 bl[84] br[84] wl[38] gnd reram_bitcell_7
Xbit_r39_c84 bl[84] br[84] wl[39] gnd reram_bitcell_7
Xbit_r40_c84 bl[84] br[84] wl[40] gnd reram_bitcell_7
Xbit_r41_c84 bl[84] br[84] wl[41] gnd reram_bitcell_7
Xbit_r42_c84 bl[84] br[84] wl[42] gnd reram_bitcell_7
Xbit_r43_c84 bl[84] br[84] wl[43] gnd reram_bitcell_7
Xbit_r44_c84 bl[84] br[84] wl[44] gnd reram_bitcell_7
Xbit_r45_c84 bl[84] br[84] wl[45] gnd reram_bitcell_7
Xbit_r46_c84 bl[84] br[84] wl[46] gnd reram_bitcell_7
Xbit_r47_c84 bl[84] br[84] wl[47] gnd reram_bitcell_7
Xbit_r48_c84 bl[84] br[84] wl[48] gnd reram_bitcell_7
Xbit_r49_c84 bl[84] br[84] wl[49] gnd reram_bitcell_7
Xbit_r50_c84 bl[84] br[84] wl[50] gnd reram_bitcell_7
Xbit_r51_c84 bl[84] br[84] wl[51] gnd reram_bitcell_7
Xbit_r52_c84 bl[84] br[84] wl[52] gnd reram_bitcell_7
Xbit_r53_c84 bl[84] br[84] wl[53] gnd reram_bitcell_7
Xbit_r54_c84 bl[84] br[84] wl[54] gnd reram_bitcell_7
Xbit_r55_c84 bl[84] br[84] wl[55] gnd reram_bitcell_7
Xbit_r56_c84 bl[84] br[84] wl[56] gnd reram_bitcell_7
Xbit_r57_c84 bl[84] br[84] wl[57] gnd reram_bitcell_7
Xbit_r58_c84 bl[84] br[84] wl[58] gnd reram_bitcell_7
Xbit_r59_c84 bl[84] br[84] wl[59] gnd reram_bitcell_7
Xbit_r60_c84 bl[84] br[84] wl[60] gnd reram_bitcell_7
Xbit_r61_c84 bl[84] br[84] wl[61] gnd reram_bitcell_7
Xbit_r62_c84 bl[84] br[84] wl[62] gnd reram_bitcell_7
Xbit_r63_c84 bl[84] br[84] wl[63] gnd reram_bitcell_7
Xbit_r0_c85 bl[85] br[85] wl[0] gnd reram_bitcell_7
Xbit_r1_c85 bl[85] br[85] wl[1] gnd reram_bitcell_7
Xbit_r2_c85 bl[85] br[85] wl[2] gnd reram_bitcell_7
Xbit_r3_c85 bl[85] br[85] wl[3] gnd reram_bitcell_7
Xbit_r4_c85 bl[85] br[85] wl[4] gnd reram_bitcell_7
Xbit_r5_c85 bl[85] br[85] wl[5] gnd reram_bitcell_7
Xbit_r6_c85 bl[85] br[85] wl[6] gnd reram_bitcell_7
Xbit_r7_c85 bl[85] br[85] wl[7] gnd reram_bitcell_7
Xbit_r8_c85 bl[85] br[85] wl[8] gnd reram_bitcell_7
Xbit_r9_c85 bl[85] br[85] wl[9] gnd reram_bitcell_7
Xbit_r10_c85 bl[85] br[85] wl[10] gnd reram_bitcell_7
Xbit_r11_c85 bl[85] br[85] wl[11] gnd reram_bitcell_7
Xbit_r12_c85 bl[85] br[85] wl[12] gnd reram_bitcell_7
Xbit_r13_c85 bl[85] br[85] wl[13] gnd reram_bitcell_7
Xbit_r14_c85 bl[85] br[85] wl[14] gnd reram_bitcell_7
Xbit_r15_c85 bl[85] br[85] wl[15] gnd reram_bitcell_7
Xbit_r16_c85 bl[85] br[85] wl[16] gnd reram_bitcell_7
Xbit_r17_c85 bl[85] br[85] wl[17] gnd reram_bitcell_7
Xbit_r18_c85 bl[85] br[85] wl[18] gnd reram_bitcell_7
Xbit_r19_c85 bl[85] br[85] wl[19] gnd reram_bitcell_7
Xbit_r20_c85 bl[85] br[85] wl[20] gnd reram_bitcell_7
Xbit_r21_c85 bl[85] br[85] wl[21] gnd reram_bitcell_7
Xbit_r22_c85 bl[85] br[85] wl[22] gnd reram_bitcell_7
Xbit_r23_c85 bl[85] br[85] wl[23] gnd reram_bitcell_7
Xbit_r24_c85 bl[85] br[85] wl[24] gnd reram_bitcell_7
Xbit_r25_c85 bl[85] br[85] wl[25] gnd reram_bitcell_7
Xbit_r26_c85 bl[85] br[85] wl[26] gnd reram_bitcell_7
Xbit_r27_c85 bl[85] br[85] wl[27] gnd reram_bitcell_7
Xbit_r28_c85 bl[85] br[85] wl[28] gnd reram_bitcell_7
Xbit_r29_c85 bl[85] br[85] wl[29] gnd reram_bitcell_7
Xbit_r30_c85 bl[85] br[85] wl[30] gnd reram_bitcell_7
Xbit_r31_c85 bl[85] br[85] wl[31] gnd reram_bitcell_7
Xbit_r32_c85 bl[85] br[85] wl[32] gnd reram_bitcell_7
Xbit_r33_c85 bl[85] br[85] wl[33] gnd reram_bitcell_7
Xbit_r34_c85 bl[85] br[85] wl[34] gnd reram_bitcell_7
Xbit_r35_c85 bl[85] br[85] wl[35] gnd reram_bitcell_7
Xbit_r36_c85 bl[85] br[85] wl[36] gnd reram_bitcell_7
Xbit_r37_c85 bl[85] br[85] wl[37] gnd reram_bitcell_7
Xbit_r38_c85 bl[85] br[85] wl[38] gnd reram_bitcell_7
Xbit_r39_c85 bl[85] br[85] wl[39] gnd reram_bitcell_7
Xbit_r40_c85 bl[85] br[85] wl[40] gnd reram_bitcell_7
Xbit_r41_c85 bl[85] br[85] wl[41] gnd reram_bitcell_7
Xbit_r42_c85 bl[85] br[85] wl[42] gnd reram_bitcell_7
Xbit_r43_c85 bl[85] br[85] wl[43] gnd reram_bitcell_7
Xbit_r44_c85 bl[85] br[85] wl[44] gnd reram_bitcell_7
Xbit_r45_c85 bl[85] br[85] wl[45] gnd reram_bitcell_7
Xbit_r46_c85 bl[85] br[85] wl[46] gnd reram_bitcell_7
Xbit_r47_c85 bl[85] br[85] wl[47] gnd reram_bitcell_7
Xbit_r48_c85 bl[85] br[85] wl[48] gnd reram_bitcell_7
Xbit_r49_c85 bl[85] br[85] wl[49] gnd reram_bitcell_7
Xbit_r50_c85 bl[85] br[85] wl[50] gnd reram_bitcell_7
Xbit_r51_c85 bl[85] br[85] wl[51] gnd reram_bitcell_7
Xbit_r52_c85 bl[85] br[85] wl[52] gnd reram_bitcell_7
Xbit_r53_c85 bl[85] br[85] wl[53] gnd reram_bitcell_7
Xbit_r54_c85 bl[85] br[85] wl[54] gnd reram_bitcell_7
Xbit_r55_c85 bl[85] br[85] wl[55] gnd reram_bitcell_7
Xbit_r56_c85 bl[85] br[85] wl[56] gnd reram_bitcell_7
Xbit_r57_c85 bl[85] br[85] wl[57] gnd reram_bitcell_7
Xbit_r58_c85 bl[85] br[85] wl[58] gnd reram_bitcell_7
Xbit_r59_c85 bl[85] br[85] wl[59] gnd reram_bitcell_7
Xbit_r60_c85 bl[85] br[85] wl[60] gnd reram_bitcell_7
Xbit_r61_c85 bl[85] br[85] wl[61] gnd reram_bitcell_7
Xbit_r62_c85 bl[85] br[85] wl[62] gnd reram_bitcell_7
Xbit_r63_c85 bl[85] br[85] wl[63] gnd reram_bitcell_7
Xbit_r0_c86 bl[86] br[86] wl[0] gnd reram_bitcell_7
Xbit_r1_c86 bl[86] br[86] wl[1] gnd reram_bitcell_7
Xbit_r2_c86 bl[86] br[86] wl[2] gnd reram_bitcell_7
Xbit_r3_c86 bl[86] br[86] wl[3] gnd reram_bitcell_7
Xbit_r4_c86 bl[86] br[86] wl[4] gnd reram_bitcell_7
Xbit_r5_c86 bl[86] br[86] wl[5] gnd reram_bitcell_7
Xbit_r6_c86 bl[86] br[86] wl[6] gnd reram_bitcell_7
Xbit_r7_c86 bl[86] br[86] wl[7] gnd reram_bitcell_7
Xbit_r8_c86 bl[86] br[86] wl[8] gnd reram_bitcell_7
Xbit_r9_c86 bl[86] br[86] wl[9] gnd reram_bitcell_7
Xbit_r10_c86 bl[86] br[86] wl[10] gnd reram_bitcell_7
Xbit_r11_c86 bl[86] br[86] wl[11] gnd reram_bitcell_7
Xbit_r12_c86 bl[86] br[86] wl[12] gnd reram_bitcell_7
Xbit_r13_c86 bl[86] br[86] wl[13] gnd reram_bitcell_7
Xbit_r14_c86 bl[86] br[86] wl[14] gnd reram_bitcell_7
Xbit_r15_c86 bl[86] br[86] wl[15] gnd reram_bitcell_7
Xbit_r16_c86 bl[86] br[86] wl[16] gnd reram_bitcell_7
Xbit_r17_c86 bl[86] br[86] wl[17] gnd reram_bitcell_7
Xbit_r18_c86 bl[86] br[86] wl[18] gnd reram_bitcell_7
Xbit_r19_c86 bl[86] br[86] wl[19] gnd reram_bitcell_7
Xbit_r20_c86 bl[86] br[86] wl[20] gnd reram_bitcell_7
Xbit_r21_c86 bl[86] br[86] wl[21] gnd reram_bitcell_7
Xbit_r22_c86 bl[86] br[86] wl[22] gnd reram_bitcell_7
Xbit_r23_c86 bl[86] br[86] wl[23] gnd reram_bitcell_7
Xbit_r24_c86 bl[86] br[86] wl[24] gnd reram_bitcell_7
Xbit_r25_c86 bl[86] br[86] wl[25] gnd reram_bitcell_7
Xbit_r26_c86 bl[86] br[86] wl[26] gnd reram_bitcell_7
Xbit_r27_c86 bl[86] br[86] wl[27] gnd reram_bitcell_7
Xbit_r28_c86 bl[86] br[86] wl[28] gnd reram_bitcell_7
Xbit_r29_c86 bl[86] br[86] wl[29] gnd reram_bitcell_7
Xbit_r30_c86 bl[86] br[86] wl[30] gnd reram_bitcell_7
Xbit_r31_c86 bl[86] br[86] wl[31] gnd reram_bitcell_7
Xbit_r32_c86 bl[86] br[86] wl[32] gnd reram_bitcell_7
Xbit_r33_c86 bl[86] br[86] wl[33] gnd reram_bitcell_7
Xbit_r34_c86 bl[86] br[86] wl[34] gnd reram_bitcell_7
Xbit_r35_c86 bl[86] br[86] wl[35] gnd reram_bitcell_7
Xbit_r36_c86 bl[86] br[86] wl[36] gnd reram_bitcell_7
Xbit_r37_c86 bl[86] br[86] wl[37] gnd reram_bitcell_7
Xbit_r38_c86 bl[86] br[86] wl[38] gnd reram_bitcell_7
Xbit_r39_c86 bl[86] br[86] wl[39] gnd reram_bitcell_7
Xbit_r40_c86 bl[86] br[86] wl[40] gnd reram_bitcell_7
Xbit_r41_c86 bl[86] br[86] wl[41] gnd reram_bitcell_7
Xbit_r42_c86 bl[86] br[86] wl[42] gnd reram_bitcell_7
Xbit_r43_c86 bl[86] br[86] wl[43] gnd reram_bitcell_7
Xbit_r44_c86 bl[86] br[86] wl[44] gnd reram_bitcell_7
Xbit_r45_c86 bl[86] br[86] wl[45] gnd reram_bitcell_7
Xbit_r46_c86 bl[86] br[86] wl[46] gnd reram_bitcell_7
Xbit_r47_c86 bl[86] br[86] wl[47] gnd reram_bitcell_7
Xbit_r48_c86 bl[86] br[86] wl[48] gnd reram_bitcell_7
Xbit_r49_c86 bl[86] br[86] wl[49] gnd reram_bitcell_7
Xbit_r50_c86 bl[86] br[86] wl[50] gnd reram_bitcell_7
Xbit_r51_c86 bl[86] br[86] wl[51] gnd reram_bitcell_7
Xbit_r52_c86 bl[86] br[86] wl[52] gnd reram_bitcell_7
Xbit_r53_c86 bl[86] br[86] wl[53] gnd reram_bitcell_7
Xbit_r54_c86 bl[86] br[86] wl[54] gnd reram_bitcell_7
Xbit_r55_c86 bl[86] br[86] wl[55] gnd reram_bitcell_7
Xbit_r56_c86 bl[86] br[86] wl[56] gnd reram_bitcell_7
Xbit_r57_c86 bl[86] br[86] wl[57] gnd reram_bitcell_7
Xbit_r58_c86 bl[86] br[86] wl[58] gnd reram_bitcell_7
Xbit_r59_c86 bl[86] br[86] wl[59] gnd reram_bitcell_7
Xbit_r60_c86 bl[86] br[86] wl[60] gnd reram_bitcell_7
Xbit_r61_c86 bl[86] br[86] wl[61] gnd reram_bitcell_7
Xbit_r62_c86 bl[86] br[86] wl[62] gnd reram_bitcell_7
Xbit_r63_c86 bl[86] br[86] wl[63] gnd reram_bitcell_7
Xbit_r0_c87 bl[87] br[87] wl[0] gnd reram_bitcell_7
Xbit_r1_c87 bl[87] br[87] wl[1] gnd reram_bitcell_7
Xbit_r2_c87 bl[87] br[87] wl[2] gnd reram_bitcell_7
Xbit_r3_c87 bl[87] br[87] wl[3] gnd reram_bitcell_7
Xbit_r4_c87 bl[87] br[87] wl[4] gnd reram_bitcell_7
Xbit_r5_c87 bl[87] br[87] wl[5] gnd reram_bitcell_7
Xbit_r6_c87 bl[87] br[87] wl[6] gnd reram_bitcell_7
Xbit_r7_c87 bl[87] br[87] wl[7] gnd reram_bitcell_7
Xbit_r8_c87 bl[87] br[87] wl[8] gnd reram_bitcell_7
Xbit_r9_c87 bl[87] br[87] wl[9] gnd reram_bitcell_7
Xbit_r10_c87 bl[87] br[87] wl[10] gnd reram_bitcell_7
Xbit_r11_c87 bl[87] br[87] wl[11] gnd reram_bitcell_7
Xbit_r12_c87 bl[87] br[87] wl[12] gnd reram_bitcell_7
Xbit_r13_c87 bl[87] br[87] wl[13] gnd reram_bitcell_7
Xbit_r14_c87 bl[87] br[87] wl[14] gnd reram_bitcell_7
Xbit_r15_c87 bl[87] br[87] wl[15] gnd reram_bitcell_7
Xbit_r16_c87 bl[87] br[87] wl[16] gnd reram_bitcell_7
Xbit_r17_c87 bl[87] br[87] wl[17] gnd reram_bitcell_7
Xbit_r18_c87 bl[87] br[87] wl[18] gnd reram_bitcell_7
Xbit_r19_c87 bl[87] br[87] wl[19] gnd reram_bitcell_7
Xbit_r20_c87 bl[87] br[87] wl[20] gnd reram_bitcell_7
Xbit_r21_c87 bl[87] br[87] wl[21] gnd reram_bitcell_7
Xbit_r22_c87 bl[87] br[87] wl[22] gnd reram_bitcell_7
Xbit_r23_c87 bl[87] br[87] wl[23] gnd reram_bitcell_7
Xbit_r24_c87 bl[87] br[87] wl[24] gnd reram_bitcell_7
Xbit_r25_c87 bl[87] br[87] wl[25] gnd reram_bitcell_7
Xbit_r26_c87 bl[87] br[87] wl[26] gnd reram_bitcell_7
Xbit_r27_c87 bl[87] br[87] wl[27] gnd reram_bitcell_7
Xbit_r28_c87 bl[87] br[87] wl[28] gnd reram_bitcell_7
Xbit_r29_c87 bl[87] br[87] wl[29] gnd reram_bitcell_7
Xbit_r30_c87 bl[87] br[87] wl[30] gnd reram_bitcell_7
Xbit_r31_c87 bl[87] br[87] wl[31] gnd reram_bitcell_7
Xbit_r32_c87 bl[87] br[87] wl[32] gnd reram_bitcell_7
Xbit_r33_c87 bl[87] br[87] wl[33] gnd reram_bitcell_7
Xbit_r34_c87 bl[87] br[87] wl[34] gnd reram_bitcell_7
Xbit_r35_c87 bl[87] br[87] wl[35] gnd reram_bitcell_7
Xbit_r36_c87 bl[87] br[87] wl[36] gnd reram_bitcell_7
Xbit_r37_c87 bl[87] br[87] wl[37] gnd reram_bitcell_7
Xbit_r38_c87 bl[87] br[87] wl[38] gnd reram_bitcell_7
Xbit_r39_c87 bl[87] br[87] wl[39] gnd reram_bitcell_7
Xbit_r40_c87 bl[87] br[87] wl[40] gnd reram_bitcell_7
Xbit_r41_c87 bl[87] br[87] wl[41] gnd reram_bitcell_7
Xbit_r42_c87 bl[87] br[87] wl[42] gnd reram_bitcell_7
Xbit_r43_c87 bl[87] br[87] wl[43] gnd reram_bitcell_7
Xbit_r44_c87 bl[87] br[87] wl[44] gnd reram_bitcell_7
Xbit_r45_c87 bl[87] br[87] wl[45] gnd reram_bitcell_7
Xbit_r46_c87 bl[87] br[87] wl[46] gnd reram_bitcell_7
Xbit_r47_c87 bl[87] br[87] wl[47] gnd reram_bitcell_7
Xbit_r48_c87 bl[87] br[87] wl[48] gnd reram_bitcell_7
Xbit_r49_c87 bl[87] br[87] wl[49] gnd reram_bitcell_7
Xbit_r50_c87 bl[87] br[87] wl[50] gnd reram_bitcell_7
Xbit_r51_c87 bl[87] br[87] wl[51] gnd reram_bitcell_7
Xbit_r52_c87 bl[87] br[87] wl[52] gnd reram_bitcell_7
Xbit_r53_c87 bl[87] br[87] wl[53] gnd reram_bitcell_7
Xbit_r54_c87 bl[87] br[87] wl[54] gnd reram_bitcell_7
Xbit_r55_c87 bl[87] br[87] wl[55] gnd reram_bitcell_7
Xbit_r56_c87 bl[87] br[87] wl[56] gnd reram_bitcell_7
Xbit_r57_c87 bl[87] br[87] wl[57] gnd reram_bitcell_7
Xbit_r58_c87 bl[87] br[87] wl[58] gnd reram_bitcell_7
Xbit_r59_c87 bl[87] br[87] wl[59] gnd reram_bitcell_7
Xbit_r60_c87 bl[87] br[87] wl[60] gnd reram_bitcell_7
Xbit_r61_c87 bl[87] br[87] wl[61] gnd reram_bitcell_7
Xbit_r62_c87 bl[87] br[87] wl[62] gnd reram_bitcell_7
Xbit_r63_c87 bl[87] br[87] wl[63] gnd reram_bitcell_7
Xbit_r0_c88 bl[88] br[88] wl[0] gnd reram_bitcell_7
Xbit_r1_c88 bl[88] br[88] wl[1] gnd reram_bitcell_7
Xbit_r2_c88 bl[88] br[88] wl[2] gnd reram_bitcell_7
Xbit_r3_c88 bl[88] br[88] wl[3] gnd reram_bitcell_7
Xbit_r4_c88 bl[88] br[88] wl[4] gnd reram_bitcell_7
Xbit_r5_c88 bl[88] br[88] wl[5] gnd reram_bitcell_7
Xbit_r6_c88 bl[88] br[88] wl[6] gnd reram_bitcell_7
Xbit_r7_c88 bl[88] br[88] wl[7] gnd reram_bitcell_7
Xbit_r8_c88 bl[88] br[88] wl[8] gnd reram_bitcell_7
Xbit_r9_c88 bl[88] br[88] wl[9] gnd reram_bitcell_7
Xbit_r10_c88 bl[88] br[88] wl[10] gnd reram_bitcell_7
Xbit_r11_c88 bl[88] br[88] wl[11] gnd reram_bitcell_7
Xbit_r12_c88 bl[88] br[88] wl[12] gnd reram_bitcell_7
Xbit_r13_c88 bl[88] br[88] wl[13] gnd reram_bitcell_7
Xbit_r14_c88 bl[88] br[88] wl[14] gnd reram_bitcell_7
Xbit_r15_c88 bl[88] br[88] wl[15] gnd reram_bitcell_7
Xbit_r16_c88 bl[88] br[88] wl[16] gnd reram_bitcell_7
Xbit_r17_c88 bl[88] br[88] wl[17] gnd reram_bitcell_7
Xbit_r18_c88 bl[88] br[88] wl[18] gnd reram_bitcell_7
Xbit_r19_c88 bl[88] br[88] wl[19] gnd reram_bitcell_7
Xbit_r20_c88 bl[88] br[88] wl[20] gnd reram_bitcell_7
Xbit_r21_c88 bl[88] br[88] wl[21] gnd reram_bitcell_7
Xbit_r22_c88 bl[88] br[88] wl[22] gnd reram_bitcell_7
Xbit_r23_c88 bl[88] br[88] wl[23] gnd reram_bitcell_7
Xbit_r24_c88 bl[88] br[88] wl[24] gnd reram_bitcell_7
Xbit_r25_c88 bl[88] br[88] wl[25] gnd reram_bitcell_7
Xbit_r26_c88 bl[88] br[88] wl[26] gnd reram_bitcell_7
Xbit_r27_c88 bl[88] br[88] wl[27] gnd reram_bitcell_7
Xbit_r28_c88 bl[88] br[88] wl[28] gnd reram_bitcell_7
Xbit_r29_c88 bl[88] br[88] wl[29] gnd reram_bitcell_7
Xbit_r30_c88 bl[88] br[88] wl[30] gnd reram_bitcell_7
Xbit_r31_c88 bl[88] br[88] wl[31] gnd reram_bitcell_7
Xbit_r32_c88 bl[88] br[88] wl[32] gnd reram_bitcell_7
Xbit_r33_c88 bl[88] br[88] wl[33] gnd reram_bitcell_7
Xbit_r34_c88 bl[88] br[88] wl[34] gnd reram_bitcell_7
Xbit_r35_c88 bl[88] br[88] wl[35] gnd reram_bitcell_7
Xbit_r36_c88 bl[88] br[88] wl[36] gnd reram_bitcell_7
Xbit_r37_c88 bl[88] br[88] wl[37] gnd reram_bitcell_7
Xbit_r38_c88 bl[88] br[88] wl[38] gnd reram_bitcell_7
Xbit_r39_c88 bl[88] br[88] wl[39] gnd reram_bitcell_7
Xbit_r40_c88 bl[88] br[88] wl[40] gnd reram_bitcell_7
Xbit_r41_c88 bl[88] br[88] wl[41] gnd reram_bitcell_7
Xbit_r42_c88 bl[88] br[88] wl[42] gnd reram_bitcell_7
Xbit_r43_c88 bl[88] br[88] wl[43] gnd reram_bitcell_7
Xbit_r44_c88 bl[88] br[88] wl[44] gnd reram_bitcell_7
Xbit_r45_c88 bl[88] br[88] wl[45] gnd reram_bitcell_7
Xbit_r46_c88 bl[88] br[88] wl[46] gnd reram_bitcell_7
Xbit_r47_c88 bl[88] br[88] wl[47] gnd reram_bitcell_7
Xbit_r48_c88 bl[88] br[88] wl[48] gnd reram_bitcell_7
Xbit_r49_c88 bl[88] br[88] wl[49] gnd reram_bitcell_7
Xbit_r50_c88 bl[88] br[88] wl[50] gnd reram_bitcell_7
Xbit_r51_c88 bl[88] br[88] wl[51] gnd reram_bitcell_7
Xbit_r52_c88 bl[88] br[88] wl[52] gnd reram_bitcell_7
Xbit_r53_c88 bl[88] br[88] wl[53] gnd reram_bitcell_7
Xbit_r54_c88 bl[88] br[88] wl[54] gnd reram_bitcell_7
Xbit_r55_c88 bl[88] br[88] wl[55] gnd reram_bitcell_7
Xbit_r56_c88 bl[88] br[88] wl[56] gnd reram_bitcell_7
Xbit_r57_c88 bl[88] br[88] wl[57] gnd reram_bitcell_7
Xbit_r58_c88 bl[88] br[88] wl[58] gnd reram_bitcell_7
Xbit_r59_c88 bl[88] br[88] wl[59] gnd reram_bitcell_7
Xbit_r60_c88 bl[88] br[88] wl[60] gnd reram_bitcell_7
Xbit_r61_c88 bl[88] br[88] wl[61] gnd reram_bitcell_7
Xbit_r62_c88 bl[88] br[88] wl[62] gnd reram_bitcell_7
Xbit_r63_c88 bl[88] br[88] wl[63] gnd reram_bitcell_7
Xbit_r0_c89 bl[89] br[89] wl[0] gnd reram_bitcell_7
Xbit_r1_c89 bl[89] br[89] wl[1] gnd reram_bitcell_7
Xbit_r2_c89 bl[89] br[89] wl[2] gnd reram_bitcell_7
Xbit_r3_c89 bl[89] br[89] wl[3] gnd reram_bitcell_7
Xbit_r4_c89 bl[89] br[89] wl[4] gnd reram_bitcell_7
Xbit_r5_c89 bl[89] br[89] wl[5] gnd reram_bitcell_7
Xbit_r6_c89 bl[89] br[89] wl[6] gnd reram_bitcell_7
Xbit_r7_c89 bl[89] br[89] wl[7] gnd reram_bitcell_7
Xbit_r8_c89 bl[89] br[89] wl[8] gnd reram_bitcell_7
Xbit_r9_c89 bl[89] br[89] wl[9] gnd reram_bitcell_7
Xbit_r10_c89 bl[89] br[89] wl[10] gnd reram_bitcell_7
Xbit_r11_c89 bl[89] br[89] wl[11] gnd reram_bitcell_7
Xbit_r12_c89 bl[89] br[89] wl[12] gnd reram_bitcell_7
Xbit_r13_c89 bl[89] br[89] wl[13] gnd reram_bitcell_7
Xbit_r14_c89 bl[89] br[89] wl[14] gnd reram_bitcell_7
Xbit_r15_c89 bl[89] br[89] wl[15] gnd reram_bitcell_7
Xbit_r16_c89 bl[89] br[89] wl[16] gnd reram_bitcell_7
Xbit_r17_c89 bl[89] br[89] wl[17] gnd reram_bitcell_7
Xbit_r18_c89 bl[89] br[89] wl[18] gnd reram_bitcell_7
Xbit_r19_c89 bl[89] br[89] wl[19] gnd reram_bitcell_7
Xbit_r20_c89 bl[89] br[89] wl[20] gnd reram_bitcell_7
Xbit_r21_c89 bl[89] br[89] wl[21] gnd reram_bitcell_7
Xbit_r22_c89 bl[89] br[89] wl[22] gnd reram_bitcell_7
Xbit_r23_c89 bl[89] br[89] wl[23] gnd reram_bitcell_7
Xbit_r24_c89 bl[89] br[89] wl[24] gnd reram_bitcell_7
Xbit_r25_c89 bl[89] br[89] wl[25] gnd reram_bitcell_7
Xbit_r26_c89 bl[89] br[89] wl[26] gnd reram_bitcell_7
Xbit_r27_c89 bl[89] br[89] wl[27] gnd reram_bitcell_7
Xbit_r28_c89 bl[89] br[89] wl[28] gnd reram_bitcell_7
Xbit_r29_c89 bl[89] br[89] wl[29] gnd reram_bitcell_7
Xbit_r30_c89 bl[89] br[89] wl[30] gnd reram_bitcell_7
Xbit_r31_c89 bl[89] br[89] wl[31] gnd reram_bitcell_7
Xbit_r32_c89 bl[89] br[89] wl[32] gnd reram_bitcell_7
Xbit_r33_c89 bl[89] br[89] wl[33] gnd reram_bitcell_7
Xbit_r34_c89 bl[89] br[89] wl[34] gnd reram_bitcell_7
Xbit_r35_c89 bl[89] br[89] wl[35] gnd reram_bitcell_7
Xbit_r36_c89 bl[89] br[89] wl[36] gnd reram_bitcell_7
Xbit_r37_c89 bl[89] br[89] wl[37] gnd reram_bitcell_7
Xbit_r38_c89 bl[89] br[89] wl[38] gnd reram_bitcell_7
Xbit_r39_c89 bl[89] br[89] wl[39] gnd reram_bitcell_7
Xbit_r40_c89 bl[89] br[89] wl[40] gnd reram_bitcell_7
Xbit_r41_c89 bl[89] br[89] wl[41] gnd reram_bitcell_7
Xbit_r42_c89 bl[89] br[89] wl[42] gnd reram_bitcell_7
Xbit_r43_c89 bl[89] br[89] wl[43] gnd reram_bitcell_7
Xbit_r44_c89 bl[89] br[89] wl[44] gnd reram_bitcell_7
Xbit_r45_c89 bl[89] br[89] wl[45] gnd reram_bitcell_7
Xbit_r46_c89 bl[89] br[89] wl[46] gnd reram_bitcell_7
Xbit_r47_c89 bl[89] br[89] wl[47] gnd reram_bitcell_7
Xbit_r48_c89 bl[89] br[89] wl[48] gnd reram_bitcell_7
Xbit_r49_c89 bl[89] br[89] wl[49] gnd reram_bitcell_7
Xbit_r50_c89 bl[89] br[89] wl[50] gnd reram_bitcell_7
Xbit_r51_c89 bl[89] br[89] wl[51] gnd reram_bitcell_7
Xbit_r52_c89 bl[89] br[89] wl[52] gnd reram_bitcell_7
Xbit_r53_c89 bl[89] br[89] wl[53] gnd reram_bitcell_7
Xbit_r54_c89 bl[89] br[89] wl[54] gnd reram_bitcell_7
Xbit_r55_c89 bl[89] br[89] wl[55] gnd reram_bitcell_7
Xbit_r56_c89 bl[89] br[89] wl[56] gnd reram_bitcell_7
Xbit_r57_c89 bl[89] br[89] wl[57] gnd reram_bitcell_7
Xbit_r58_c89 bl[89] br[89] wl[58] gnd reram_bitcell_7
Xbit_r59_c89 bl[89] br[89] wl[59] gnd reram_bitcell_7
Xbit_r60_c89 bl[89] br[89] wl[60] gnd reram_bitcell_7
Xbit_r61_c89 bl[89] br[89] wl[61] gnd reram_bitcell_7
Xbit_r62_c89 bl[89] br[89] wl[62] gnd reram_bitcell_7
Xbit_r63_c89 bl[89] br[89] wl[63] gnd reram_bitcell_7
Xbit_r0_c90 bl[90] br[90] wl[0] gnd reram_bitcell_7
Xbit_r1_c90 bl[90] br[90] wl[1] gnd reram_bitcell_7
Xbit_r2_c90 bl[90] br[90] wl[2] gnd reram_bitcell_7
Xbit_r3_c90 bl[90] br[90] wl[3] gnd reram_bitcell_7
Xbit_r4_c90 bl[90] br[90] wl[4] gnd reram_bitcell_7
Xbit_r5_c90 bl[90] br[90] wl[5] gnd reram_bitcell_7
Xbit_r6_c90 bl[90] br[90] wl[6] gnd reram_bitcell_7
Xbit_r7_c90 bl[90] br[90] wl[7] gnd reram_bitcell_7
Xbit_r8_c90 bl[90] br[90] wl[8] gnd reram_bitcell_7
Xbit_r9_c90 bl[90] br[90] wl[9] gnd reram_bitcell_7
Xbit_r10_c90 bl[90] br[90] wl[10] gnd reram_bitcell_7
Xbit_r11_c90 bl[90] br[90] wl[11] gnd reram_bitcell_7
Xbit_r12_c90 bl[90] br[90] wl[12] gnd reram_bitcell_7
Xbit_r13_c90 bl[90] br[90] wl[13] gnd reram_bitcell_7
Xbit_r14_c90 bl[90] br[90] wl[14] gnd reram_bitcell_7
Xbit_r15_c90 bl[90] br[90] wl[15] gnd reram_bitcell_7
Xbit_r16_c90 bl[90] br[90] wl[16] gnd reram_bitcell_7
Xbit_r17_c90 bl[90] br[90] wl[17] gnd reram_bitcell_7
Xbit_r18_c90 bl[90] br[90] wl[18] gnd reram_bitcell_7
Xbit_r19_c90 bl[90] br[90] wl[19] gnd reram_bitcell_7
Xbit_r20_c90 bl[90] br[90] wl[20] gnd reram_bitcell_7
Xbit_r21_c90 bl[90] br[90] wl[21] gnd reram_bitcell_7
Xbit_r22_c90 bl[90] br[90] wl[22] gnd reram_bitcell_7
Xbit_r23_c90 bl[90] br[90] wl[23] gnd reram_bitcell_7
Xbit_r24_c90 bl[90] br[90] wl[24] gnd reram_bitcell_7
Xbit_r25_c90 bl[90] br[90] wl[25] gnd reram_bitcell_7
Xbit_r26_c90 bl[90] br[90] wl[26] gnd reram_bitcell_7
Xbit_r27_c90 bl[90] br[90] wl[27] gnd reram_bitcell_7
Xbit_r28_c90 bl[90] br[90] wl[28] gnd reram_bitcell_7
Xbit_r29_c90 bl[90] br[90] wl[29] gnd reram_bitcell_7
Xbit_r30_c90 bl[90] br[90] wl[30] gnd reram_bitcell_7
Xbit_r31_c90 bl[90] br[90] wl[31] gnd reram_bitcell_7
Xbit_r32_c90 bl[90] br[90] wl[32] gnd reram_bitcell_7
Xbit_r33_c90 bl[90] br[90] wl[33] gnd reram_bitcell_7
Xbit_r34_c90 bl[90] br[90] wl[34] gnd reram_bitcell_7
Xbit_r35_c90 bl[90] br[90] wl[35] gnd reram_bitcell_7
Xbit_r36_c90 bl[90] br[90] wl[36] gnd reram_bitcell_7
Xbit_r37_c90 bl[90] br[90] wl[37] gnd reram_bitcell_7
Xbit_r38_c90 bl[90] br[90] wl[38] gnd reram_bitcell_7
Xbit_r39_c90 bl[90] br[90] wl[39] gnd reram_bitcell_7
Xbit_r40_c90 bl[90] br[90] wl[40] gnd reram_bitcell_7
Xbit_r41_c90 bl[90] br[90] wl[41] gnd reram_bitcell_7
Xbit_r42_c90 bl[90] br[90] wl[42] gnd reram_bitcell_7
Xbit_r43_c90 bl[90] br[90] wl[43] gnd reram_bitcell_7
Xbit_r44_c90 bl[90] br[90] wl[44] gnd reram_bitcell_7
Xbit_r45_c90 bl[90] br[90] wl[45] gnd reram_bitcell_7
Xbit_r46_c90 bl[90] br[90] wl[46] gnd reram_bitcell_7
Xbit_r47_c90 bl[90] br[90] wl[47] gnd reram_bitcell_7
Xbit_r48_c90 bl[90] br[90] wl[48] gnd reram_bitcell_7
Xbit_r49_c90 bl[90] br[90] wl[49] gnd reram_bitcell_7
Xbit_r50_c90 bl[90] br[90] wl[50] gnd reram_bitcell_7
Xbit_r51_c90 bl[90] br[90] wl[51] gnd reram_bitcell_7
Xbit_r52_c90 bl[90] br[90] wl[52] gnd reram_bitcell_7
Xbit_r53_c90 bl[90] br[90] wl[53] gnd reram_bitcell_7
Xbit_r54_c90 bl[90] br[90] wl[54] gnd reram_bitcell_7
Xbit_r55_c90 bl[90] br[90] wl[55] gnd reram_bitcell_7
Xbit_r56_c90 bl[90] br[90] wl[56] gnd reram_bitcell_7
Xbit_r57_c90 bl[90] br[90] wl[57] gnd reram_bitcell_7
Xbit_r58_c90 bl[90] br[90] wl[58] gnd reram_bitcell_7
Xbit_r59_c90 bl[90] br[90] wl[59] gnd reram_bitcell_7
Xbit_r60_c90 bl[90] br[90] wl[60] gnd reram_bitcell_7
Xbit_r61_c90 bl[90] br[90] wl[61] gnd reram_bitcell_7
Xbit_r62_c90 bl[90] br[90] wl[62] gnd reram_bitcell_7
Xbit_r63_c90 bl[90] br[90] wl[63] gnd reram_bitcell_7
Xbit_r0_c91 bl[91] br[91] wl[0] gnd reram_bitcell_7
Xbit_r1_c91 bl[91] br[91] wl[1] gnd reram_bitcell_7
Xbit_r2_c91 bl[91] br[91] wl[2] gnd reram_bitcell_7
Xbit_r3_c91 bl[91] br[91] wl[3] gnd reram_bitcell_7
Xbit_r4_c91 bl[91] br[91] wl[4] gnd reram_bitcell_7
Xbit_r5_c91 bl[91] br[91] wl[5] gnd reram_bitcell_7
Xbit_r6_c91 bl[91] br[91] wl[6] gnd reram_bitcell_7
Xbit_r7_c91 bl[91] br[91] wl[7] gnd reram_bitcell_7
Xbit_r8_c91 bl[91] br[91] wl[8] gnd reram_bitcell_7
Xbit_r9_c91 bl[91] br[91] wl[9] gnd reram_bitcell_7
Xbit_r10_c91 bl[91] br[91] wl[10] gnd reram_bitcell_7
Xbit_r11_c91 bl[91] br[91] wl[11] gnd reram_bitcell_7
Xbit_r12_c91 bl[91] br[91] wl[12] gnd reram_bitcell_7
Xbit_r13_c91 bl[91] br[91] wl[13] gnd reram_bitcell_7
Xbit_r14_c91 bl[91] br[91] wl[14] gnd reram_bitcell_7
Xbit_r15_c91 bl[91] br[91] wl[15] gnd reram_bitcell_7
Xbit_r16_c91 bl[91] br[91] wl[16] gnd reram_bitcell_7
Xbit_r17_c91 bl[91] br[91] wl[17] gnd reram_bitcell_7
Xbit_r18_c91 bl[91] br[91] wl[18] gnd reram_bitcell_7
Xbit_r19_c91 bl[91] br[91] wl[19] gnd reram_bitcell_7
Xbit_r20_c91 bl[91] br[91] wl[20] gnd reram_bitcell_7
Xbit_r21_c91 bl[91] br[91] wl[21] gnd reram_bitcell_7
Xbit_r22_c91 bl[91] br[91] wl[22] gnd reram_bitcell_7
Xbit_r23_c91 bl[91] br[91] wl[23] gnd reram_bitcell_7
Xbit_r24_c91 bl[91] br[91] wl[24] gnd reram_bitcell_7
Xbit_r25_c91 bl[91] br[91] wl[25] gnd reram_bitcell_7
Xbit_r26_c91 bl[91] br[91] wl[26] gnd reram_bitcell_7
Xbit_r27_c91 bl[91] br[91] wl[27] gnd reram_bitcell_7
Xbit_r28_c91 bl[91] br[91] wl[28] gnd reram_bitcell_7
Xbit_r29_c91 bl[91] br[91] wl[29] gnd reram_bitcell_7
Xbit_r30_c91 bl[91] br[91] wl[30] gnd reram_bitcell_7
Xbit_r31_c91 bl[91] br[91] wl[31] gnd reram_bitcell_7
Xbit_r32_c91 bl[91] br[91] wl[32] gnd reram_bitcell_7
Xbit_r33_c91 bl[91] br[91] wl[33] gnd reram_bitcell_7
Xbit_r34_c91 bl[91] br[91] wl[34] gnd reram_bitcell_7
Xbit_r35_c91 bl[91] br[91] wl[35] gnd reram_bitcell_7
Xbit_r36_c91 bl[91] br[91] wl[36] gnd reram_bitcell_7
Xbit_r37_c91 bl[91] br[91] wl[37] gnd reram_bitcell_7
Xbit_r38_c91 bl[91] br[91] wl[38] gnd reram_bitcell_7
Xbit_r39_c91 bl[91] br[91] wl[39] gnd reram_bitcell_7
Xbit_r40_c91 bl[91] br[91] wl[40] gnd reram_bitcell_7
Xbit_r41_c91 bl[91] br[91] wl[41] gnd reram_bitcell_7
Xbit_r42_c91 bl[91] br[91] wl[42] gnd reram_bitcell_7
Xbit_r43_c91 bl[91] br[91] wl[43] gnd reram_bitcell_7
Xbit_r44_c91 bl[91] br[91] wl[44] gnd reram_bitcell_7
Xbit_r45_c91 bl[91] br[91] wl[45] gnd reram_bitcell_7
Xbit_r46_c91 bl[91] br[91] wl[46] gnd reram_bitcell_7
Xbit_r47_c91 bl[91] br[91] wl[47] gnd reram_bitcell_7
Xbit_r48_c91 bl[91] br[91] wl[48] gnd reram_bitcell_7
Xbit_r49_c91 bl[91] br[91] wl[49] gnd reram_bitcell_7
Xbit_r50_c91 bl[91] br[91] wl[50] gnd reram_bitcell_7
Xbit_r51_c91 bl[91] br[91] wl[51] gnd reram_bitcell_7
Xbit_r52_c91 bl[91] br[91] wl[52] gnd reram_bitcell_7
Xbit_r53_c91 bl[91] br[91] wl[53] gnd reram_bitcell_7
Xbit_r54_c91 bl[91] br[91] wl[54] gnd reram_bitcell_7
Xbit_r55_c91 bl[91] br[91] wl[55] gnd reram_bitcell_7
Xbit_r56_c91 bl[91] br[91] wl[56] gnd reram_bitcell_7
Xbit_r57_c91 bl[91] br[91] wl[57] gnd reram_bitcell_7
Xbit_r58_c91 bl[91] br[91] wl[58] gnd reram_bitcell_7
Xbit_r59_c91 bl[91] br[91] wl[59] gnd reram_bitcell_7
Xbit_r60_c91 bl[91] br[91] wl[60] gnd reram_bitcell_7
Xbit_r61_c91 bl[91] br[91] wl[61] gnd reram_bitcell_7
Xbit_r62_c91 bl[91] br[91] wl[62] gnd reram_bitcell_7
Xbit_r63_c91 bl[91] br[91] wl[63] gnd reram_bitcell_7
Xbit_r0_c92 bl[92] br[92] wl[0] gnd reram_bitcell_7
Xbit_r1_c92 bl[92] br[92] wl[1] gnd reram_bitcell_7
Xbit_r2_c92 bl[92] br[92] wl[2] gnd reram_bitcell_7
Xbit_r3_c92 bl[92] br[92] wl[3] gnd reram_bitcell_7
Xbit_r4_c92 bl[92] br[92] wl[4] gnd reram_bitcell_7
Xbit_r5_c92 bl[92] br[92] wl[5] gnd reram_bitcell_7
Xbit_r6_c92 bl[92] br[92] wl[6] gnd reram_bitcell_7
Xbit_r7_c92 bl[92] br[92] wl[7] gnd reram_bitcell_7
Xbit_r8_c92 bl[92] br[92] wl[8] gnd reram_bitcell_7
Xbit_r9_c92 bl[92] br[92] wl[9] gnd reram_bitcell_7
Xbit_r10_c92 bl[92] br[92] wl[10] gnd reram_bitcell_7
Xbit_r11_c92 bl[92] br[92] wl[11] gnd reram_bitcell_7
Xbit_r12_c92 bl[92] br[92] wl[12] gnd reram_bitcell_7
Xbit_r13_c92 bl[92] br[92] wl[13] gnd reram_bitcell_7
Xbit_r14_c92 bl[92] br[92] wl[14] gnd reram_bitcell_7
Xbit_r15_c92 bl[92] br[92] wl[15] gnd reram_bitcell_7
Xbit_r16_c92 bl[92] br[92] wl[16] gnd reram_bitcell_7
Xbit_r17_c92 bl[92] br[92] wl[17] gnd reram_bitcell_7
Xbit_r18_c92 bl[92] br[92] wl[18] gnd reram_bitcell_7
Xbit_r19_c92 bl[92] br[92] wl[19] gnd reram_bitcell_7
Xbit_r20_c92 bl[92] br[92] wl[20] gnd reram_bitcell_7
Xbit_r21_c92 bl[92] br[92] wl[21] gnd reram_bitcell_7
Xbit_r22_c92 bl[92] br[92] wl[22] gnd reram_bitcell_7
Xbit_r23_c92 bl[92] br[92] wl[23] gnd reram_bitcell_7
Xbit_r24_c92 bl[92] br[92] wl[24] gnd reram_bitcell_7
Xbit_r25_c92 bl[92] br[92] wl[25] gnd reram_bitcell_7
Xbit_r26_c92 bl[92] br[92] wl[26] gnd reram_bitcell_7
Xbit_r27_c92 bl[92] br[92] wl[27] gnd reram_bitcell_7
Xbit_r28_c92 bl[92] br[92] wl[28] gnd reram_bitcell_7
Xbit_r29_c92 bl[92] br[92] wl[29] gnd reram_bitcell_7
Xbit_r30_c92 bl[92] br[92] wl[30] gnd reram_bitcell_7
Xbit_r31_c92 bl[92] br[92] wl[31] gnd reram_bitcell_7
Xbit_r32_c92 bl[92] br[92] wl[32] gnd reram_bitcell_7
Xbit_r33_c92 bl[92] br[92] wl[33] gnd reram_bitcell_7
Xbit_r34_c92 bl[92] br[92] wl[34] gnd reram_bitcell_7
Xbit_r35_c92 bl[92] br[92] wl[35] gnd reram_bitcell_7
Xbit_r36_c92 bl[92] br[92] wl[36] gnd reram_bitcell_7
Xbit_r37_c92 bl[92] br[92] wl[37] gnd reram_bitcell_7
Xbit_r38_c92 bl[92] br[92] wl[38] gnd reram_bitcell_7
Xbit_r39_c92 bl[92] br[92] wl[39] gnd reram_bitcell_7
Xbit_r40_c92 bl[92] br[92] wl[40] gnd reram_bitcell_7
Xbit_r41_c92 bl[92] br[92] wl[41] gnd reram_bitcell_7
Xbit_r42_c92 bl[92] br[92] wl[42] gnd reram_bitcell_7
Xbit_r43_c92 bl[92] br[92] wl[43] gnd reram_bitcell_7
Xbit_r44_c92 bl[92] br[92] wl[44] gnd reram_bitcell_7
Xbit_r45_c92 bl[92] br[92] wl[45] gnd reram_bitcell_7
Xbit_r46_c92 bl[92] br[92] wl[46] gnd reram_bitcell_7
Xbit_r47_c92 bl[92] br[92] wl[47] gnd reram_bitcell_7
Xbit_r48_c92 bl[92] br[92] wl[48] gnd reram_bitcell_7
Xbit_r49_c92 bl[92] br[92] wl[49] gnd reram_bitcell_7
Xbit_r50_c92 bl[92] br[92] wl[50] gnd reram_bitcell_7
Xbit_r51_c92 bl[92] br[92] wl[51] gnd reram_bitcell_7
Xbit_r52_c92 bl[92] br[92] wl[52] gnd reram_bitcell_7
Xbit_r53_c92 bl[92] br[92] wl[53] gnd reram_bitcell_7
Xbit_r54_c92 bl[92] br[92] wl[54] gnd reram_bitcell_7
Xbit_r55_c92 bl[92] br[92] wl[55] gnd reram_bitcell_7
Xbit_r56_c92 bl[92] br[92] wl[56] gnd reram_bitcell_7
Xbit_r57_c92 bl[92] br[92] wl[57] gnd reram_bitcell_7
Xbit_r58_c92 bl[92] br[92] wl[58] gnd reram_bitcell_7
Xbit_r59_c92 bl[92] br[92] wl[59] gnd reram_bitcell_7
Xbit_r60_c92 bl[92] br[92] wl[60] gnd reram_bitcell_7
Xbit_r61_c92 bl[92] br[92] wl[61] gnd reram_bitcell_7
Xbit_r62_c92 bl[92] br[92] wl[62] gnd reram_bitcell_7
Xbit_r63_c92 bl[92] br[92] wl[63] gnd reram_bitcell_7
Xbit_r0_c93 bl[93] br[93] wl[0] gnd reram_bitcell_7
Xbit_r1_c93 bl[93] br[93] wl[1] gnd reram_bitcell_7
Xbit_r2_c93 bl[93] br[93] wl[2] gnd reram_bitcell_7
Xbit_r3_c93 bl[93] br[93] wl[3] gnd reram_bitcell_7
Xbit_r4_c93 bl[93] br[93] wl[4] gnd reram_bitcell_7
Xbit_r5_c93 bl[93] br[93] wl[5] gnd reram_bitcell_7
Xbit_r6_c93 bl[93] br[93] wl[6] gnd reram_bitcell_7
Xbit_r7_c93 bl[93] br[93] wl[7] gnd reram_bitcell_7
Xbit_r8_c93 bl[93] br[93] wl[8] gnd reram_bitcell_7
Xbit_r9_c93 bl[93] br[93] wl[9] gnd reram_bitcell_7
Xbit_r10_c93 bl[93] br[93] wl[10] gnd reram_bitcell_7
Xbit_r11_c93 bl[93] br[93] wl[11] gnd reram_bitcell_7
Xbit_r12_c93 bl[93] br[93] wl[12] gnd reram_bitcell_7
Xbit_r13_c93 bl[93] br[93] wl[13] gnd reram_bitcell_7
Xbit_r14_c93 bl[93] br[93] wl[14] gnd reram_bitcell_7
Xbit_r15_c93 bl[93] br[93] wl[15] gnd reram_bitcell_7
Xbit_r16_c93 bl[93] br[93] wl[16] gnd reram_bitcell_7
Xbit_r17_c93 bl[93] br[93] wl[17] gnd reram_bitcell_7
Xbit_r18_c93 bl[93] br[93] wl[18] gnd reram_bitcell_7
Xbit_r19_c93 bl[93] br[93] wl[19] gnd reram_bitcell_7
Xbit_r20_c93 bl[93] br[93] wl[20] gnd reram_bitcell_7
Xbit_r21_c93 bl[93] br[93] wl[21] gnd reram_bitcell_7
Xbit_r22_c93 bl[93] br[93] wl[22] gnd reram_bitcell_7
Xbit_r23_c93 bl[93] br[93] wl[23] gnd reram_bitcell_7
Xbit_r24_c93 bl[93] br[93] wl[24] gnd reram_bitcell_7
Xbit_r25_c93 bl[93] br[93] wl[25] gnd reram_bitcell_7
Xbit_r26_c93 bl[93] br[93] wl[26] gnd reram_bitcell_7
Xbit_r27_c93 bl[93] br[93] wl[27] gnd reram_bitcell_7
Xbit_r28_c93 bl[93] br[93] wl[28] gnd reram_bitcell_7
Xbit_r29_c93 bl[93] br[93] wl[29] gnd reram_bitcell_7
Xbit_r30_c93 bl[93] br[93] wl[30] gnd reram_bitcell_7
Xbit_r31_c93 bl[93] br[93] wl[31] gnd reram_bitcell_7
Xbit_r32_c93 bl[93] br[93] wl[32] gnd reram_bitcell_7
Xbit_r33_c93 bl[93] br[93] wl[33] gnd reram_bitcell_7
Xbit_r34_c93 bl[93] br[93] wl[34] gnd reram_bitcell_7
Xbit_r35_c93 bl[93] br[93] wl[35] gnd reram_bitcell_7
Xbit_r36_c93 bl[93] br[93] wl[36] gnd reram_bitcell_7
Xbit_r37_c93 bl[93] br[93] wl[37] gnd reram_bitcell_7
Xbit_r38_c93 bl[93] br[93] wl[38] gnd reram_bitcell_7
Xbit_r39_c93 bl[93] br[93] wl[39] gnd reram_bitcell_7
Xbit_r40_c93 bl[93] br[93] wl[40] gnd reram_bitcell_7
Xbit_r41_c93 bl[93] br[93] wl[41] gnd reram_bitcell_7
Xbit_r42_c93 bl[93] br[93] wl[42] gnd reram_bitcell_7
Xbit_r43_c93 bl[93] br[93] wl[43] gnd reram_bitcell_7
Xbit_r44_c93 bl[93] br[93] wl[44] gnd reram_bitcell_7
Xbit_r45_c93 bl[93] br[93] wl[45] gnd reram_bitcell_7
Xbit_r46_c93 bl[93] br[93] wl[46] gnd reram_bitcell_7
Xbit_r47_c93 bl[93] br[93] wl[47] gnd reram_bitcell_7
Xbit_r48_c93 bl[93] br[93] wl[48] gnd reram_bitcell_7
Xbit_r49_c93 bl[93] br[93] wl[49] gnd reram_bitcell_7
Xbit_r50_c93 bl[93] br[93] wl[50] gnd reram_bitcell_7
Xbit_r51_c93 bl[93] br[93] wl[51] gnd reram_bitcell_7
Xbit_r52_c93 bl[93] br[93] wl[52] gnd reram_bitcell_7
Xbit_r53_c93 bl[93] br[93] wl[53] gnd reram_bitcell_7
Xbit_r54_c93 bl[93] br[93] wl[54] gnd reram_bitcell_7
Xbit_r55_c93 bl[93] br[93] wl[55] gnd reram_bitcell_7
Xbit_r56_c93 bl[93] br[93] wl[56] gnd reram_bitcell_7
Xbit_r57_c93 bl[93] br[93] wl[57] gnd reram_bitcell_7
Xbit_r58_c93 bl[93] br[93] wl[58] gnd reram_bitcell_7
Xbit_r59_c93 bl[93] br[93] wl[59] gnd reram_bitcell_7
Xbit_r60_c93 bl[93] br[93] wl[60] gnd reram_bitcell_7
Xbit_r61_c93 bl[93] br[93] wl[61] gnd reram_bitcell_7
Xbit_r62_c93 bl[93] br[93] wl[62] gnd reram_bitcell_7
Xbit_r63_c93 bl[93] br[93] wl[63] gnd reram_bitcell_7
Xbit_r0_c94 bl[94] br[94] wl[0] gnd reram_bitcell_7
Xbit_r1_c94 bl[94] br[94] wl[1] gnd reram_bitcell_7
Xbit_r2_c94 bl[94] br[94] wl[2] gnd reram_bitcell_7
Xbit_r3_c94 bl[94] br[94] wl[3] gnd reram_bitcell_7
Xbit_r4_c94 bl[94] br[94] wl[4] gnd reram_bitcell_7
Xbit_r5_c94 bl[94] br[94] wl[5] gnd reram_bitcell_7
Xbit_r6_c94 bl[94] br[94] wl[6] gnd reram_bitcell_7
Xbit_r7_c94 bl[94] br[94] wl[7] gnd reram_bitcell_7
Xbit_r8_c94 bl[94] br[94] wl[8] gnd reram_bitcell_7
Xbit_r9_c94 bl[94] br[94] wl[9] gnd reram_bitcell_7
Xbit_r10_c94 bl[94] br[94] wl[10] gnd reram_bitcell_7
Xbit_r11_c94 bl[94] br[94] wl[11] gnd reram_bitcell_7
Xbit_r12_c94 bl[94] br[94] wl[12] gnd reram_bitcell_7
Xbit_r13_c94 bl[94] br[94] wl[13] gnd reram_bitcell_7
Xbit_r14_c94 bl[94] br[94] wl[14] gnd reram_bitcell_7
Xbit_r15_c94 bl[94] br[94] wl[15] gnd reram_bitcell_7
Xbit_r16_c94 bl[94] br[94] wl[16] gnd reram_bitcell_7
Xbit_r17_c94 bl[94] br[94] wl[17] gnd reram_bitcell_7
Xbit_r18_c94 bl[94] br[94] wl[18] gnd reram_bitcell_7
Xbit_r19_c94 bl[94] br[94] wl[19] gnd reram_bitcell_7
Xbit_r20_c94 bl[94] br[94] wl[20] gnd reram_bitcell_7
Xbit_r21_c94 bl[94] br[94] wl[21] gnd reram_bitcell_7
Xbit_r22_c94 bl[94] br[94] wl[22] gnd reram_bitcell_7
Xbit_r23_c94 bl[94] br[94] wl[23] gnd reram_bitcell_7
Xbit_r24_c94 bl[94] br[94] wl[24] gnd reram_bitcell_7
Xbit_r25_c94 bl[94] br[94] wl[25] gnd reram_bitcell_7
Xbit_r26_c94 bl[94] br[94] wl[26] gnd reram_bitcell_7
Xbit_r27_c94 bl[94] br[94] wl[27] gnd reram_bitcell_7
Xbit_r28_c94 bl[94] br[94] wl[28] gnd reram_bitcell_7
Xbit_r29_c94 bl[94] br[94] wl[29] gnd reram_bitcell_7
Xbit_r30_c94 bl[94] br[94] wl[30] gnd reram_bitcell_7
Xbit_r31_c94 bl[94] br[94] wl[31] gnd reram_bitcell_7
Xbit_r32_c94 bl[94] br[94] wl[32] gnd reram_bitcell_7
Xbit_r33_c94 bl[94] br[94] wl[33] gnd reram_bitcell_7
Xbit_r34_c94 bl[94] br[94] wl[34] gnd reram_bitcell_7
Xbit_r35_c94 bl[94] br[94] wl[35] gnd reram_bitcell_7
Xbit_r36_c94 bl[94] br[94] wl[36] gnd reram_bitcell_7
Xbit_r37_c94 bl[94] br[94] wl[37] gnd reram_bitcell_7
Xbit_r38_c94 bl[94] br[94] wl[38] gnd reram_bitcell_7
Xbit_r39_c94 bl[94] br[94] wl[39] gnd reram_bitcell_7
Xbit_r40_c94 bl[94] br[94] wl[40] gnd reram_bitcell_7
Xbit_r41_c94 bl[94] br[94] wl[41] gnd reram_bitcell_7
Xbit_r42_c94 bl[94] br[94] wl[42] gnd reram_bitcell_7
Xbit_r43_c94 bl[94] br[94] wl[43] gnd reram_bitcell_7
Xbit_r44_c94 bl[94] br[94] wl[44] gnd reram_bitcell_7
Xbit_r45_c94 bl[94] br[94] wl[45] gnd reram_bitcell_7
Xbit_r46_c94 bl[94] br[94] wl[46] gnd reram_bitcell_7
Xbit_r47_c94 bl[94] br[94] wl[47] gnd reram_bitcell_7
Xbit_r48_c94 bl[94] br[94] wl[48] gnd reram_bitcell_7
Xbit_r49_c94 bl[94] br[94] wl[49] gnd reram_bitcell_7
Xbit_r50_c94 bl[94] br[94] wl[50] gnd reram_bitcell_7
Xbit_r51_c94 bl[94] br[94] wl[51] gnd reram_bitcell_7
Xbit_r52_c94 bl[94] br[94] wl[52] gnd reram_bitcell_7
Xbit_r53_c94 bl[94] br[94] wl[53] gnd reram_bitcell_7
Xbit_r54_c94 bl[94] br[94] wl[54] gnd reram_bitcell_7
Xbit_r55_c94 bl[94] br[94] wl[55] gnd reram_bitcell_7
Xbit_r56_c94 bl[94] br[94] wl[56] gnd reram_bitcell_7
Xbit_r57_c94 bl[94] br[94] wl[57] gnd reram_bitcell_7
Xbit_r58_c94 bl[94] br[94] wl[58] gnd reram_bitcell_7
Xbit_r59_c94 bl[94] br[94] wl[59] gnd reram_bitcell_7
Xbit_r60_c94 bl[94] br[94] wl[60] gnd reram_bitcell_7
Xbit_r61_c94 bl[94] br[94] wl[61] gnd reram_bitcell_7
Xbit_r62_c94 bl[94] br[94] wl[62] gnd reram_bitcell_7
Xbit_r63_c94 bl[94] br[94] wl[63] gnd reram_bitcell_7
Xbit_r0_c95 bl[95] br[95] wl[0] gnd reram_bitcell_7
Xbit_r1_c95 bl[95] br[95] wl[1] gnd reram_bitcell_7
Xbit_r2_c95 bl[95] br[95] wl[2] gnd reram_bitcell_7
Xbit_r3_c95 bl[95] br[95] wl[3] gnd reram_bitcell_7
Xbit_r4_c95 bl[95] br[95] wl[4] gnd reram_bitcell_7
Xbit_r5_c95 bl[95] br[95] wl[5] gnd reram_bitcell_7
Xbit_r6_c95 bl[95] br[95] wl[6] gnd reram_bitcell_7
Xbit_r7_c95 bl[95] br[95] wl[7] gnd reram_bitcell_7
Xbit_r8_c95 bl[95] br[95] wl[8] gnd reram_bitcell_7
Xbit_r9_c95 bl[95] br[95] wl[9] gnd reram_bitcell_7
Xbit_r10_c95 bl[95] br[95] wl[10] gnd reram_bitcell_7
Xbit_r11_c95 bl[95] br[95] wl[11] gnd reram_bitcell_7
Xbit_r12_c95 bl[95] br[95] wl[12] gnd reram_bitcell_7
Xbit_r13_c95 bl[95] br[95] wl[13] gnd reram_bitcell_7
Xbit_r14_c95 bl[95] br[95] wl[14] gnd reram_bitcell_7
Xbit_r15_c95 bl[95] br[95] wl[15] gnd reram_bitcell_7
Xbit_r16_c95 bl[95] br[95] wl[16] gnd reram_bitcell_7
Xbit_r17_c95 bl[95] br[95] wl[17] gnd reram_bitcell_7
Xbit_r18_c95 bl[95] br[95] wl[18] gnd reram_bitcell_7
Xbit_r19_c95 bl[95] br[95] wl[19] gnd reram_bitcell_7
Xbit_r20_c95 bl[95] br[95] wl[20] gnd reram_bitcell_7
Xbit_r21_c95 bl[95] br[95] wl[21] gnd reram_bitcell_7
Xbit_r22_c95 bl[95] br[95] wl[22] gnd reram_bitcell_7
Xbit_r23_c95 bl[95] br[95] wl[23] gnd reram_bitcell_7
Xbit_r24_c95 bl[95] br[95] wl[24] gnd reram_bitcell_7
Xbit_r25_c95 bl[95] br[95] wl[25] gnd reram_bitcell_7
Xbit_r26_c95 bl[95] br[95] wl[26] gnd reram_bitcell_7
Xbit_r27_c95 bl[95] br[95] wl[27] gnd reram_bitcell_7
Xbit_r28_c95 bl[95] br[95] wl[28] gnd reram_bitcell_7
Xbit_r29_c95 bl[95] br[95] wl[29] gnd reram_bitcell_7
Xbit_r30_c95 bl[95] br[95] wl[30] gnd reram_bitcell_7
Xbit_r31_c95 bl[95] br[95] wl[31] gnd reram_bitcell_7
Xbit_r32_c95 bl[95] br[95] wl[32] gnd reram_bitcell_7
Xbit_r33_c95 bl[95] br[95] wl[33] gnd reram_bitcell_7
Xbit_r34_c95 bl[95] br[95] wl[34] gnd reram_bitcell_7
Xbit_r35_c95 bl[95] br[95] wl[35] gnd reram_bitcell_7
Xbit_r36_c95 bl[95] br[95] wl[36] gnd reram_bitcell_7
Xbit_r37_c95 bl[95] br[95] wl[37] gnd reram_bitcell_7
Xbit_r38_c95 bl[95] br[95] wl[38] gnd reram_bitcell_7
Xbit_r39_c95 bl[95] br[95] wl[39] gnd reram_bitcell_7
Xbit_r40_c95 bl[95] br[95] wl[40] gnd reram_bitcell_7
Xbit_r41_c95 bl[95] br[95] wl[41] gnd reram_bitcell_7
Xbit_r42_c95 bl[95] br[95] wl[42] gnd reram_bitcell_7
Xbit_r43_c95 bl[95] br[95] wl[43] gnd reram_bitcell_7
Xbit_r44_c95 bl[95] br[95] wl[44] gnd reram_bitcell_7
Xbit_r45_c95 bl[95] br[95] wl[45] gnd reram_bitcell_7
Xbit_r46_c95 bl[95] br[95] wl[46] gnd reram_bitcell_7
Xbit_r47_c95 bl[95] br[95] wl[47] gnd reram_bitcell_7
Xbit_r48_c95 bl[95] br[95] wl[48] gnd reram_bitcell_7
Xbit_r49_c95 bl[95] br[95] wl[49] gnd reram_bitcell_7
Xbit_r50_c95 bl[95] br[95] wl[50] gnd reram_bitcell_7
Xbit_r51_c95 bl[95] br[95] wl[51] gnd reram_bitcell_7
Xbit_r52_c95 bl[95] br[95] wl[52] gnd reram_bitcell_7
Xbit_r53_c95 bl[95] br[95] wl[53] gnd reram_bitcell_7
Xbit_r54_c95 bl[95] br[95] wl[54] gnd reram_bitcell_7
Xbit_r55_c95 bl[95] br[95] wl[55] gnd reram_bitcell_7
Xbit_r56_c95 bl[95] br[95] wl[56] gnd reram_bitcell_7
Xbit_r57_c95 bl[95] br[95] wl[57] gnd reram_bitcell_7
Xbit_r58_c95 bl[95] br[95] wl[58] gnd reram_bitcell_7
Xbit_r59_c95 bl[95] br[95] wl[59] gnd reram_bitcell_7
Xbit_r60_c95 bl[95] br[95] wl[60] gnd reram_bitcell_7
Xbit_r61_c95 bl[95] br[95] wl[61] gnd reram_bitcell_7
Xbit_r62_c95 bl[95] br[95] wl[62] gnd reram_bitcell_7
Xbit_r63_c95 bl[95] br[95] wl[63] gnd reram_bitcell_7
Xbit_r0_c96 bl[96] br[96] wl[0] gnd reram_bitcell_7
Xbit_r1_c96 bl[96] br[96] wl[1] gnd reram_bitcell_7
Xbit_r2_c96 bl[96] br[96] wl[2] gnd reram_bitcell_7
Xbit_r3_c96 bl[96] br[96] wl[3] gnd reram_bitcell_7
Xbit_r4_c96 bl[96] br[96] wl[4] gnd reram_bitcell_7
Xbit_r5_c96 bl[96] br[96] wl[5] gnd reram_bitcell_7
Xbit_r6_c96 bl[96] br[96] wl[6] gnd reram_bitcell_7
Xbit_r7_c96 bl[96] br[96] wl[7] gnd reram_bitcell_7
Xbit_r8_c96 bl[96] br[96] wl[8] gnd reram_bitcell_7
Xbit_r9_c96 bl[96] br[96] wl[9] gnd reram_bitcell_7
Xbit_r10_c96 bl[96] br[96] wl[10] gnd reram_bitcell_7
Xbit_r11_c96 bl[96] br[96] wl[11] gnd reram_bitcell_7
Xbit_r12_c96 bl[96] br[96] wl[12] gnd reram_bitcell_7
Xbit_r13_c96 bl[96] br[96] wl[13] gnd reram_bitcell_7
Xbit_r14_c96 bl[96] br[96] wl[14] gnd reram_bitcell_7
Xbit_r15_c96 bl[96] br[96] wl[15] gnd reram_bitcell_7
Xbit_r16_c96 bl[96] br[96] wl[16] gnd reram_bitcell_7
Xbit_r17_c96 bl[96] br[96] wl[17] gnd reram_bitcell_7
Xbit_r18_c96 bl[96] br[96] wl[18] gnd reram_bitcell_7
Xbit_r19_c96 bl[96] br[96] wl[19] gnd reram_bitcell_7
Xbit_r20_c96 bl[96] br[96] wl[20] gnd reram_bitcell_7
Xbit_r21_c96 bl[96] br[96] wl[21] gnd reram_bitcell_7
Xbit_r22_c96 bl[96] br[96] wl[22] gnd reram_bitcell_7
Xbit_r23_c96 bl[96] br[96] wl[23] gnd reram_bitcell_7
Xbit_r24_c96 bl[96] br[96] wl[24] gnd reram_bitcell_7
Xbit_r25_c96 bl[96] br[96] wl[25] gnd reram_bitcell_7
Xbit_r26_c96 bl[96] br[96] wl[26] gnd reram_bitcell_7
Xbit_r27_c96 bl[96] br[96] wl[27] gnd reram_bitcell_7
Xbit_r28_c96 bl[96] br[96] wl[28] gnd reram_bitcell_7
Xbit_r29_c96 bl[96] br[96] wl[29] gnd reram_bitcell_7
Xbit_r30_c96 bl[96] br[96] wl[30] gnd reram_bitcell_7
Xbit_r31_c96 bl[96] br[96] wl[31] gnd reram_bitcell_7
Xbit_r32_c96 bl[96] br[96] wl[32] gnd reram_bitcell_7
Xbit_r33_c96 bl[96] br[96] wl[33] gnd reram_bitcell_7
Xbit_r34_c96 bl[96] br[96] wl[34] gnd reram_bitcell_7
Xbit_r35_c96 bl[96] br[96] wl[35] gnd reram_bitcell_7
Xbit_r36_c96 bl[96] br[96] wl[36] gnd reram_bitcell_7
Xbit_r37_c96 bl[96] br[96] wl[37] gnd reram_bitcell_7
Xbit_r38_c96 bl[96] br[96] wl[38] gnd reram_bitcell_7
Xbit_r39_c96 bl[96] br[96] wl[39] gnd reram_bitcell_7
Xbit_r40_c96 bl[96] br[96] wl[40] gnd reram_bitcell_7
Xbit_r41_c96 bl[96] br[96] wl[41] gnd reram_bitcell_7
Xbit_r42_c96 bl[96] br[96] wl[42] gnd reram_bitcell_7
Xbit_r43_c96 bl[96] br[96] wl[43] gnd reram_bitcell_7
Xbit_r44_c96 bl[96] br[96] wl[44] gnd reram_bitcell_7
Xbit_r45_c96 bl[96] br[96] wl[45] gnd reram_bitcell_7
Xbit_r46_c96 bl[96] br[96] wl[46] gnd reram_bitcell_7
Xbit_r47_c96 bl[96] br[96] wl[47] gnd reram_bitcell_7
Xbit_r48_c96 bl[96] br[96] wl[48] gnd reram_bitcell_7
Xbit_r49_c96 bl[96] br[96] wl[49] gnd reram_bitcell_7
Xbit_r50_c96 bl[96] br[96] wl[50] gnd reram_bitcell_7
Xbit_r51_c96 bl[96] br[96] wl[51] gnd reram_bitcell_7
Xbit_r52_c96 bl[96] br[96] wl[52] gnd reram_bitcell_7
Xbit_r53_c96 bl[96] br[96] wl[53] gnd reram_bitcell_7
Xbit_r54_c96 bl[96] br[96] wl[54] gnd reram_bitcell_7
Xbit_r55_c96 bl[96] br[96] wl[55] gnd reram_bitcell_7
Xbit_r56_c96 bl[96] br[96] wl[56] gnd reram_bitcell_7
Xbit_r57_c96 bl[96] br[96] wl[57] gnd reram_bitcell_7
Xbit_r58_c96 bl[96] br[96] wl[58] gnd reram_bitcell_7
Xbit_r59_c96 bl[96] br[96] wl[59] gnd reram_bitcell_7
Xbit_r60_c96 bl[96] br[96] wl[60] gnd reram_bitcell_7
Xbit_r61_c96 bl[96] br[96] wl[61] gnd reram_bitcell_7
Xbit_r62_c96 bl[96] br[96] wl[62] gnd reram_bitcell_7
Xbit_r63_c96 bl[96] br[96] wl[63] gnd reram_bitcell_7
Xbit_r0_c97 bl[97] br[97] wl[0] gnd reram_bitcell_7
Xbit_r1_c97 bl[97] br[97] wl[1] gnd reram_bitcell_7
Xbit_r2_c97 bl[97] br[97] wl[2] gnd reram_bitcell_7
Xbit_r3_c97 bl[97] br[97] wl[3] gnd reram_bitcell_7
Xbit_r4_c97 bl[97] br[97] wl[4] gnd reram_bitcell_7
Xbit_r5_c97 bl[97] br[97] wl[5] gnd reram_bitcell_7
Xbit_r6_c97 bl[97] br[97] wl[6] gnd reram_bitcell_7
Xbit_r7_c97 bl[97] br[97] wl[7] gnd reram_bitcell_7
Xbit_r8_c97 bl[97] br[97] wl[8] gnd reram_bitcell_7
Xbit_r9_c97 bl[97] br[97] wl[9] gnd reram_bitcell_7
Xbit_r10_c97 bl[97] br[97] wl[10] gnd reram_bitcell_7
Xbit_r11_c97 bl[97] br[97] wl[11] gnd reram_bitcell_7
Xbit_r12_c97 bl[97] br[97] wl[12] gnd reram_bitcell_7
Xbit_r13_c97 bl[97] br[97] wl[13] gnd reram_bitcell_7
Xbit_r14_c97 bl[97] br[97] wl[14] gnd reram_bitcell_7
Xbit_r15_c97 bl[97] br[97] wl[15] gnd reram_bitcell_7
Xbit_r16_c97 bl[97] br[97] wl[16] gnd reram_bitcell_7
Xbit_r17_c97 bl[97] br[97] wl[17] gnd reram_bitcell_7
Xbit_r18_c97 bl[97] br[97] wl[18] gnd reram_bitcell_7
Xbit_r19_c97 bl[97] br[97] wl[19] gnd reram_bitcell_7
Xbit_r20_c97 bl[97] br[97] wl[20] gnd reram_bitcell_7
Xbit_r21_c97 bl[97] br[97] wl[21] gnd reram_bitcell_7
Xbit_r22_c97 bl[97] br[97] wl[22] gnd reram_bitcell_7
Xbit_r23_c97 bl[97] br[97] wl[23] gnd reram_bitcell_7
Xbit_r24_c97 bl[97] br[97] wl[24] gnd reram_bitcell_7
Xbit_r25_c97 bl[97] br[97] wl[25] gnd reram_bitcell_7
Xbit_r26_c97 bl[97] br[97] wl[26] gnd reram_bitcell_7
Xbit_r27_c97 bl[97] br[97] wl[27] gnd reram_bitcell_7
Xbit_r28_c97 bl[97] br[97] wl[28] gnd reram_bitcell_7
Xbit_r29_c97 bl[97] br[97] wl[29] gnd reram_bitcell_7
Xbit_r30_c97 bl[97] br[97] wl[30] gnd reram_bitcell_7
Xbit_r31_c97 bl[97] br[97] wl[31] gnd reram_bitcell_7
Xbit_r32_c97 bl[97] br[97] wl[32] gnd reram_bitcell_7
Xbit_r33_c97 bl[97] br[97] wl[33] gnd reram_bitcell_7
Xbit_r34_c97 bl[97] br[97] wl[34] gnd reram_bitcell_7
Xbit_r35_c97 bl[97] br[97] wl[35] gnd reram_bitcell_7
Xbit_r36_c97 bl[97] br[97] wl[36] gnd reram_bitcell_7
Xbit_r37_c97 bl[97] br[97] wl[37] gnd reram_bitcell_7
Xbit_r38_c97 bl[97] br[97] wl[38] gnd reram_bitcell_7
Xbit_r39_c97 bl[97] br[97] wl[39] gnd reram_bitcell_7
Xbit_r40_c97 bl[97] br[97] wl[40] gnd reram_bitcell_7
Xbit_r41_c97 bl[97] br[97] wl[41] gnd reram_bitcell_7
Xbit_r42_c97 bl[97] br[97] wl[42] gnd reram_bitcell_7
Xbit_r43_c97 bl[97] br[97] wl[43] gnd reram_bitcell_7
Xbit_r44_c97 bl[97] br[97] wl[44] gnd reram_bitcell_7
Xbit_r45_c97 bl[97] br[97] wl[45] gnd reram_bitcell_7
Xbit_r46_c97 bl[97] br[97] wl[46] gnd reram_bitcell_7
Xbit_r47_c97 bl[97] br[97] wl[47] gnd reram_bitcell_7
Xbit_r48_c97 bl[97] br[97] wl[48] gnd reram_bitcell_7
Xbit_r49_c97 bl[97] br[97] wl[49] gnd reram_bitcell_7
Xbit_r50_c97 bl[97] br[97] wl[50] gnd reram_bitcell_7
Xbit_r51_c97 bl[97] br[97] wl[51] gnd reram_bitcell_7
Xbit_r52_c97 bl[97] br[97] wl[52] gnd reram_bitcell_7
Xbit_r53_c97 bl[97] br[97] wl[53] gnd reram_bitcell_7
Xbit_r54_c97 bl[97] br[97] wl[54] gnd reram_bitcell_7
Xbit_r55_c97 bl[97] br[97] wl[55] gnd reram_bitcell_7
Xbit_r56_c97 bl[97] br[97] wl[56] gnd reram_bitcell_7
Xbit_r57_c97 bl[97] br[97] wl[57] gnd reram_bitcell_7
Xbit_r58_c97 bl[97] br[97] wl[58] gnd reram_bitcell_7
Xbit_r59_c97 bl[97] br[97] wl[59] gnd reram_bitcell_7
Xbit_r60_c97 bl[97] br[97] wl[60] gnd reram_bitcell_7
Xbit_r61_c97 bl[97] br[97] wl[61] gnd reram_bitcell_7
Xbit_r62_c97 bl[97] br[97] wl[62] gnd reram_bitcell_7
Xbit_r63_c97 bl[97] br[97] wl[63] gnd reram_bitcell_7
Xbit_r0_c98 bl[98] br[98] wl[0] gnd reram_bitcell_7
Xbit_r1_c98 bl[98] br[98] wl[1] gnd reram_bitcell_7
Xbit_r2_c98 bl[98] br[98] wl[2] gnd reram_bitcell_7
Xbit_r3_c98 bl[98] br[98] wl[3] gnd reram_bitcell_7
Xbit_r4_c98 bl[98] br[98] wl[4] gnd reram_bitcell_7
Xbit_r5_c98 bl[98] br[98] wl[5] gnd reram_bitcell_7
Xbit_r6_c98 bl[98] br[98] wl[6] gnd reram_bitcell_7
Xbit_r7_c98 bl[98] br[98] wl[7] gnd reram_bitcell_7
Xbit_r8_c98 bl[98] br[98] wl[8] gnd reram_bitcell_7
Xbit_r9_c98 bl[98] br[98] wl[9] gnd reram_bitcell_7
Xbit_r10_c98 bl[98] br[98] wl[10] gnd reram_bitcell_7
Xbit_r11_c98 bl[98] br[98] wl[11] gnd reram_bitcell_7
Xbit_r12_c98 bl[98] br[98] wl[12] gnd reram_bitcell_7
Xbit_r13_c98 bl[98] br[98] wl[13] gnd reram_bitcell_7
Xbit_r14_c98 bl[98] br[98] wl[14] gnd reram_bitcell_7
Xbit_r15_c98 bl[98] br[98] wl[15] gnd reram_bitcell_7
Xbit_r16_c98 bl[98] br[98] wl[16] gnd reram_bitcell_7
Xbit_r17_c98 bl[98] br[98] wl[17] gnd reram_bitcell_7
Xbit_r18_c98 bl[98] br[98] wl[18] gnd reram_bitcell_7
Xbit_r19_c98 bl[98] br[98] wl[19] gnd reram_bitcell_7
Xbit_r20_c98 bl[98] br[98] wl[20] gnd reram_bitcell_7
Xbit_r21_c98 bl[98] br[98] wl[21] gnd reram_bitcell_7
Xbit_r22_c98 bl[98] br[98] wl[22] gnd reram_bitcell_7
Xbit_r23_c98 bl[98] br[98] wl[23] gnd reram_bitcell_7
Xbit_r24_c98 bl[98] br[98] wl[24] gnd reram_bitcell_7
Xbit_r25_c98 bl[98] br[98] wl[25] gnd reram_bitcell_7
Xbit_r26_c98 bl[98] br[98] wl[26] gnd reram_bitcell_7
Xbit_r27_c98 bl[98] br[98] wl[27] gnd reram_bitcell_7
Xbit_r28_c98 bl[98] br[98] wl[28] gnd reram_bitcell_7
Xbit_r29_c98 bl[98] br[98] wl[29] gnd reram_bitcell_7
Xbit_r30_c98 bl[98] br[98] wl[30] gnd reram_bitcell_7
Xbit_r31_c98 bl[98] br[98] wl[31] gnd reram_bitcell_7
Xbit_r32_c98 bl[98] br[98] wl[32] gnd reram_bitcell_7
Xbit_r33_c98 bl[98] br[98] wl[33] gnd reram_bitcell_7
Xbit_r34_c98 bl[98] br[98] wl[34] gnd reram_bitcell_7
Xbit_r35_c98 bl[98] br[98] wl[35] gnd reram_bitcell_7
Xbit_r36_c98 bl[98] br[98] wl[36] gnd reram_bitcell_7
Xbit_r37_c98 bl[98] br[98] wl[37] gnd reram_bitcell_7
Xbit_r38_c98 bl[98] br[98] wl[38] gnd reram_bitcell_7
Xbit_r39_c98 bl[98] br[98] wl[39] gnd reram_bitcell_7
Xbit_r40_c98 bl[98] br[98] wl[40] gnd reram_bitcell_7
Xbit_r41_c98 bl[98] br[98] wl[41] gnd reram_bitcell_7
Xbit_r42_c98 bl[98] br[98] wl[42] gnd reram_bitcell_7
Xbit_r43_c98 bl[98] br[98] wl[43] gnd reram_bitcell_7
Xbit_r44_c98 bl[98] br[98] wl[44] gnd reram_bitcell_7
Xbit_r45_c98 bl[98] br[98] wl[45] gnd reram_bitcell_7
Xbit_r46_c98 bl[98] br[98] wl[46] gnd reram_bitcell_7
Xbit_r47_c98 bl[98] br[98] wl[47] gnd reram_bitcell_7
Xbit_r48_c98 bl[98] br[98] wl[48] gnd reram_bitcell_7
Xbit_r49_c98 bl[98] br[98] wl[49] gnd reram_bitcell_7
Xbit_r50_c98 bl[98] br[98] wl[50] gnd reram_bitcell_7
Xbit_r51_c98 bl[98] br[98] wl[51] gnd reram_bitcell_7
Xbit_r52_c98 bl[98] br[98] wl[52] gnd reram_bitcell_7
Xbit_r53_c98 bl[98] br[98] wl[53] gnd reram_bitcell_7
Xbit_r54_c98 bl[98] br[98] wl[54] gnd reram_bitcell_7
Xbit_r55_c98 bl[98] br[98] wl[55] gnd reram_bitcell_7
Xbit_r56_c98 bl[98] br[98] wl[56] gnd reram_bitcell_7
Xbit_r57_c98 bl[98] br[98] wl[57] gnd reram_bitcell_7
Xbit_r58_c98 bl[98] br[98] wl[58] gnd reram_bitcell_7
Xbit_r59_c98 bl[98] br[98] wl[59] gnd reram_bitcell_7
Xbit_r60_c98 bl[98] br[98] wl[60] gnd reram_bitcell_7
Xbit_r61_c98 bl[98] br[98] wl[61] gnd reram_bitcell_7
Xbit_r62_c98 bl[98] br[98] wl[62] gnd reram_bitcell_7
Xbit_r63_c98 bl[98] br[98] wl[63] gnd reram_bitcell_7
Xbit_r0_c99 bl[99] br[99] wl[0] gnd reram_bitcell_7
Xbit_r1_c99 bl[99] br[99] wl[1] gnd reram_bitcell_7
Xbit_r2_c99 bl[99] br[99] wl[2] gnd reram_bitcell_7
Xbit_r3_c99 bl[99] br[99] wl[3] gnd reram_bitcell_7
Xbit_r4_c99 bl[99] br[99] wl[4] gnd reram_bitcell_7
Xbit_r5_c99 bl[99] br[99] wl[5] gnd reram_bitcell_7
Xbit_r6_c99 bl[99] br[99] wl[6] gnd reram_bitcell_7
Xbit_r7_c99 bl[99] br[99] wl[7] gnd reram_bitcell_7
Xbit_r8_c99 bl[99] br[99] wl[8] gnd reram_bitcell_7
Xbit_r9_c99 bl[99] br[99] wl[9] gnd reram_bitcell_7
Xbit_r10_c99 bl[99] br[99] wl[10] gnd reram_bitcell_7
Xbit_r11_c99 bl[99] br[99] wl[11] gnd reram_bitcell_7
Xbit_r12_c99 bl[99] br[99] wl[12] gnd reram_bitcell_7
Xbit_r13_c99 bl[99] br[99] wl[13] gnd reram_bitcell_7
Xbit_r14_c99 bl[99] br[99] wl[14] gnd reram_bitcell_7
Xbit_r15_c99 bl[99] br[99] wl[15] gnd reram_bitcell_7
Xbit_r16_c99 bl[99] br[99] wl[16] gnd reram_bitcell_7
Xbit_r17_c99 bl[99] br[99] wl[17] gnd reram_bitcell_7
Xbit_r18_c99 bl[99] br[99] wl[18] gnd reram_bitcell_7
Xbit_r19_c99 bl[99] br[99] wl[19] gnd reram_bitcell_7
Xbit_r20_c99 bl[99] br[99] wl[20] gnd reram_bitcell_7
Xbit_r21_c99 bl[99] br[99] wl[21] gnd reram_bitcell_7
Xbit_r22_c99 bl[99] br[99] wl[22] gnd reram_bitcell_7
Xbit_r23_c99 bl[99] br[99] wl[23] gnd reram_bitcell_7
Xbit_r24_c99 bl[99] br[99] wl[24] gnd reram_bitcell_7
Xbit_r25_c99 bl[99] br[99] wl[25] gnd reram_bitcell_7
Xbit_r26_c99 bl[99] br[99] wl[26] gnd reram_bitcell_7
Xbit_r27_c99 bl[99] br[99] wl[27] gnd reram_bitcell_7
Xbit_r28_c99 bl[99] br[99] wl[28] gnd reram_bitcell_7
Xbit_r29_c99 bl[99] br[99] wl[29] gnd reram_bitcell_7
Xbit_r30_c99 bl[99] br[99] wl[30] gnd reram_bitcell_7
Xbit_r31_c99 bl[99] br[99] wl[31] gnd reram_bitcell_7
Xbit_r32_c99 bl[99] br[99] wl[32] gnd reram_bitcell_7
Xbit_r33_c99 bl[99] br[99] wl[33] gnd reram_bitcell_7
Xbit_r34_c99 bl[99] br[99] wl[34] gnd reram_bitcell_7
Xbit_r35_c99 bl[99] br[99] wl[35] gnd reram_bitcell_7
Xbit_r36_c99 bl[99] br[99] wl[36] gnd reram_bitcell_7
Xbit_r37_c99 bl[99] br[99] wl[37] gnd reram_bitcell_7
Xbit_r38_c99 bl[99] br[99] wl[38] gnd reram_bitcell_7
Xbit_r39_c99 bl[99] br[99] wl[39] gnd reram_bitcell_7
Xbit_r40_c99 bl[99] br[99] wl[40] gnd reram_bitcell_7
Xbit_r41_c99 bl[99] br[99] wl[41] gnd reram_bitcell_7
Xbit_r42_c99 bl[99] br[99] wl[42] gnd reram_bitcell_7
Xbit_r43_c99 bl[99] br[99] wl[43] gnd reram_bitcell_7
Xbit_r44_c99 bl[99] br[99] wl[44] gnd reram_bitcell_7
Xbit_r45_c99 bl[99] br[99] wl[45] gnd reram_bitcell_7
Xbit_r46_c99 bl[99] br[99] wl[46] gnd reram_bitcell_7
Xbit_r47_c99 bl[99] br[99] wl[47] gnd reram_bitcell_7
Xbit_r48_c99 bl[99] br[99] wl[48] gnd reram_bitcell_7
Xbit_r49_c99 bl[99] br[99] wl[49] gnd reram_bitcell_7
Xbit_r50_c99 bl[99] br[99] wl[50] gnd reram_bitcell_7
Xbit_r51_c99 bl[99] br[99] wl[51] gnd reram_bitcell_7
Xbit_r52_c99 bl[99] br[99] wl[52] gnd reram_bitcell_7
Xbit_r53_c99 bl[99] br[99] wl[53] gnd reram_bitcell_7
Xbit_r54_c99 bl[99] br[99] wl[54] gnd reram_bitcell_7
Xbit_r55_c99 bl[99] br[99] wl[55] gnd reram_bitcell_7
Xbit_r56_c99 bl[99] br[99] wl[56] gnd reram_bitcell_7
Xbit_r57_c99 bl[99] br[99] wl[57] gnd reram_bitcell_7
Xbit_r58_c99 bl[99] br[99] wl[58] gnd reram_bitcell_7
Xbit_r59_c99 bl[99] br[99] wl[59] gnd reram_bitcell_7
Xbit_r60_c99 bl[99] br[99] wl[60] gnd reram_bitcell_7
Xbit_r61_c99 bl[99] br[99] wl[61] gnd reram_bitcell_7
Xbit_r62_c99 bl[99] br[99] wl[62] gnd reram_bitcell_7
Xbit_r63_c99 bl[99] br[99] wl[63] gnd reram_bitcell_7
Xbit_r0_c100 bl[100] br[100] wl[0] gnd reram_bitcell_7
Xbit_r1_c100 bl[100] br[100] wl[1] gnd reram_bitcell_7
Xbit_r2_c100 bl[100] br[100] wl[2] gnd reram_bitcell_7
Xbit_r3_c100 bl[100] br[100] wl[3] gnd reram_bitcell_7
Xbit_r4_c100 bl[100] br[100] wl[4] gnd reram_bitcell_7
Xbit_r5_c100 bl[100] br[100] wl[5] gnd reram_bitcell_7
Xbit_r6_c100 bl[100] br[100] wl[6] gnd reram_bitcell_7
Xbit_r7_c100 bl[100] br[100] wl[7] gnd reram_bitcell_7
Xbit_r8_c100 bl[100] br[100] wl[8] gnd reram_bitcell_7
Xbit_r9_c100 bl[100] br[100] wl[9] gnd reram_bitcell_7
Xbit_r10_c100 bl[100] br[100] wl[10] gnd reram_bitcell_7
Xbit_r11_c100 bl[100] br[100] wl[11] gnd reram_bitcell_7
Xbit_r12_c100 bl[100] br[100] wl[12] gnd reram_bitcell_7
Xbit_r13_c100 bl[100] br[100] wl[13] gnd reram_bitcell_7
Xbit_r14_c100 bl[100] br[100] wl[14] gnd reram_bitcell_7
Xbit_r15_c100 bl[100] br[100] wl[15] gnd reram_bitcell_7
Xbit_r16_c100 bl[100] br[100] wl[16] gnd reram_bitcell_7
Xbit_r17_c100 bl[100] br[100] wl[17] gnd reram_bitcell_7
Xbit_r18_c100 bl[100] br[100] wl[18] gnd reram_bitcell_7
Xbit_r19_c100 bl[100] br[100] wl[19] gnd reram_bitcell_7
Xbit_r20_c100 bl[100] br[100] wl[20] gnd reram_bitcell_7
Xbit_r21_c100 bl[100] br[100] wl[21] gnd reram_bitcell_7
Xbit_r22_c100 bl[100] br[100] wl[22] gnd reram_bitcell_7
Xbit_r23_c100 bl[100] br[100] wl[23] gnd reram_bitcell_7
Xbit_r24_c100 bl[100] br[100] wl[24] gnd reram_bitcell_7
Xbit_r25_c100 bl[100] br[100] wl[25] gnd reram_bitcell_7
Xbit_r26_c100 bl[100] br[100] wl[26] gnd reram_bitcell_7
Xbit_r27_c100 bl[100] br[100] wl[27] gnd reram_bitcell_7
Xbit_r28_c100 bl[100] br[100] wl[28] gnd reram_bitcell_7
Xbit_r29_c100 bl[100] br[100] wl[29] gnd reram_bitcell_7
Xbit_r30_c100 bl[100] br[100] wl[30] gnd reram_bitcell_7
Xbit_r31_c100 bl[100] br[100] wl[31] gnd reram_bitcell_7
Xbit_r32_c100 bl[100] br[100] wl[32] gnd reram_bitcell_7
Xbit_r33_c100 bl[100] br[100] wl[33] gnd reram_bitcell_7
Xbit_r34_c100 bl[100] br[100] wl[34] gnd reram_bitcell_7
Xbit_r35_c100 bl[100] br[100] wl[35] gnd reram_bitcell_7
Xbit_r36_c100 bl[100] br[100] wl[36] gnd reram_bitcell_7
Xbit_r37_c100 bl[100] br[100] wl[37] gnd reram_bitcell_7
Xbit_r38_c100 bl[100] br[100] wl[38] gnd reram_bitcell_7
Xbit_r39_c100 bl[100] br[100] wl[39] gnd reram_bitcell_7
Xbit_r40_c100 bl[100] br[100] wl[40] gnd reram_bitcell_7
Xbit_r41_c100 bl[100] br[100] wl[41] gnd reram_bitcell_7
Xbit_r42_c100 bl[100] br[100] wl[42] gnd reram_bitcell_7
Xbit_r43_c100 bl[100] br[100] wl[43] gnd reram_bitcell_7
Xbit_r44_c100 bl[100] br[100] wl[44] gnd reram_bitcell_7
Xbit_r45_c100 bl[100] br[100] wl[45] gnd reram_bitcell_7
Xbit_r46_c100 bl[100] br[100] wl[46] gnd reram_bitcell_7
Xbit_r47_c100 bl[100] br[100] wl[47] gnd reram_bitcell_7
Xbit_r48_c100 bl[100] br[100] wl[48] gnd reram_bitcell_7
Xbit_r49_c100 bl[100] br[100] wl[49] gnd reram_bitcell_7
Xbit_r50_c100 bl[100] br[100] wl[50] gnd reram_bitcell_7
Xbit_r51_c100 bl[100] br[100] wl[51] gnd reram_bitcell_7
Xbit_r52_c100 bl[100] br[100] wl[52] gnd reram_bitcell_7
Xbit_r53_c100 bl[100] br[100] wl[53] gnd reram_bitcell_7
Xbit_r54_c100 bl[100] br[100] wl[54] gnd reram_bitcell_7
Xbit_r55_c100 bl[100] br[100] wl[55] gnd reram_bitcell_7
Xbit_r56_c100 bl[100] br[100] wl[56] gnd reram_bitcell_7
Xbit_r57_c100 bl[100] br[100] wl[57] gnd reram_bitcell_7
Xbit_r58_c100 bl[100] br[100] wl[58] gnd reram_bitcell_7
Xbit_r59_c100 bl[100] br[100] wl[59] gnd reram_bitcell_7
Xbit_r60_c100 bl[100] br[100] wl[60] gnd reram_bitcell_7
Xbit_r61_c100 bl[100] br[100] wl[61] gnd reram_bitcell_7
Xbit_r62_c100 bl[100] br[100] wl[62] gnd reram_bitcell_7
Xbit_r63_c100 bl[100] br[100] wl[63] gnd reram_bitcell_7
Xbit_r0_c101 bl[101] br[101] wl[0] gnd reram_bitcell_7
Xbit_r1_c101 bl[101] br[101] wl[1] gnd reram_bitcell_7
Xbit_r2_c101 bl[101] br[101] wl[2] gnd reram_bitcell_7
Xbit_r3_c101 bl[101] br[101] wl[3] gnd reram_bitcell_7
Xbit_r4_c101 bl[101] br[101] wl[4] gnd reram_bitcell_7
Xbit_r5_c101 bl[101] br[101] wl[5] gnd reram_bitcell_7
Xbit_r6_c101 bl[101] br[101] wl[6] gnd reram_bitcell_7
Xbit_r7_c101 bl[101] br[101] wl[7] gnd reram_bitcell_7
Xbit_r8_c101 bl[101] br[101] wl[8] gnd reram_bitcell_7
Xbit_r9_c101 bl[101] br[101] wl[9] gnd reram_bitcell_7
Xbit_r10_c101 bl[101] br[101] wl[10] gnd reram_bitcell_7
Xbit_r11_c101 bl[101] br[101] wl[11] gnd reram_bitcell_7
Xbit_r12_c101 bl[101] br[101] wl[12] gnd reram_bitcell_7
Xbit_r13_c101 bl[101] br[101] wl[13] gnd reram_bitcell_7
Xbit_r14_c101 bl[101] br[101] wl[14] gnd reram_bitcell_7
Xbit_r15_c101 bl[101] br[101] wl[15] gnd reram_bitcell_7
Xbit_r16_c101 bl[101] br[101] wl[16] gnd reram_bitcell_7
Xbit_r17_c101 bl[101] br[101] wl[17] gnd reram_bitcell_7
Xbit_r18_c101 bl[101] br[101] wl[18] gnd reram_bitcell_7
Xbit_r19_c101 bl[101] br[101] wl[19] gnd reram_bitcell_7
Xbit_r20_c101 bl[101] br[101] wl[20] gnd reram_bitcell_7
Xbit_r21_c101 bl[101] br[101] wl[21] gnd reram_bitcell_7
Xbit_r22_c101 bl[101] br[101] wl[22] gnd reram_bitcell_7
Xbit_r23_c101 bl[101] br[101] wl[23] gnd reram_bitcell_7
Xbit_r24_c101 bl[101] br[101] wl[24] gnd reram_bitcell_7
Xbit_r25_c101 bl[101] br[101] wl[25] gnd reram_bitcell_7
Xbit_r26_c101 bl[101] br[101] wl[26] gnd reram_bitcell_7
Xbit_r27_c101 bl[101] br[101] wl[27] gnd reram_bitcell_7
Xbit_r28_c101 bl[101] br[101] wl[28] gnd reram_bitcell_7
Xbit_r29_c101 bl[101] br[101] wl[29] gnd reram_bitcell_7
Xbit_r30_c101 bl[101] br[101] wl[30] gnd reram_bitcell_7
Xbit_r31_c101 bl[101] br[101] wl[31] gnd reram_bitcell_7
Xbit_r32_c101 bl[101] br[101] wl[32] gnd reram_bitcell_7
Xbit_r33_c101 bl[101] br[101] wl[33] gnd reram_bitcell_7
Xbit_r34_c101 bl[101] br[101] wl[34] gnd reram_bitcell_7
Xbit_r35_c101 bl[101] br[101] wl[35] gnd reram_bitcell_7
Xbit_r36_c101 bl[101] br[101] wl[36] gnd reram_bitcell_7
Xbit_r37_c101 bl[101] br[101] wl[37] gnd reram_bitcell_7
Xbit_r38_c101 bl[101] br[101] wl[38] gnd reram_bitcell_7
Xbit_r39_c101 bl[101] br[101] wl[39] gnd reram_bitcell_7
Xbit_r40_c101 bl[101] br[101] wl[40] gnd reram_bitcell_7
Xbit_r41_c101 bl[101] br[101] wl[41] gnd reram_bitcell_7
Xbit_r42_c101 bl[101] br[101] wl[42] gnd reram_bitcell_7
Xbit_r43_c101 bl[101] br[101] wl[43] gnd reram_bitcell_7
Xbit_r44_c101 bl[101] br[101] wl[44] gnd reram_bitcell_7
Xbit_r45_c101 bl[101] br[101] wl[45] gnd reram_bitcell_7
Xbit_r46_c101 bl[101] br[101] wl[46] gnd reram_bitcell_7
Xbit_r47_c101 bl[101] br[101] wl[47] gnd reram_bitcell_7
Xbit_r48_c101 bl[101] br[101] wl[48] gnd reram_bitcell_7
Xbit_r49_c101 bl[101] br[101] wl[49] gnd reram_bitcell_7
Xbit_r50_c101 bl[101] br[101] wl[50] gnd reram_bitcell_7
Xbit_r51_c101 bl[101] br[101] wl[51] gnd reram_bitcell_7
Xbit_r52_c101 bl[101] br[101] wl[52] gnd reram_bitcell_7
Xbit_r53_c101 bl[101] br[101] wl[53] gnd reram_bitcell_7
Xbit_r54_c101 bl[101] br[101] wl[54] gnd reram_bitcell_7
Xbit_r55_c101 bl[101] br[101] wl[55] gnd reram_bitcell_7
Xbit_r56_c101 bl[101] br[101] wl[56] gnd reram_bitcell_7
Xbit_r57_c101 bl[101] br[101] wl[57] gnd reram_bitcell_7
Xbit_r58_c101 bl[101] br[101] wl[58] gnd reram_bitcell_7
Xbit_r59_c101 bl[101] br[101] wl[59] gnd reram_bitcell_7
Xbit_r60_c101 bl[101] br[101] wl[60] gnd reram_bitcell_7
Xbit_r61_c101 bl[101] br[101] wl[61] gnd reram_bitcell_7
Xbit_r62_c101 bl[101] br[101] wl[62] gnd reram_bitcell_7
Xbit_r63_c101 bl[101] br[101] wl[63] gnd reram_bitcell_7
Xbit_r0_c102 bl[102] br[102] wl[0] gnd reram_bitcell_7
Xbit_r1_c102 bl[102] br[102] wl[1] gnd reram_bitcell_7
Xbit_r2_c102 bl[102] br[102] wl[2] gnd reram_bitcell_7
Xbit_r3_c102 bl[102] br[102] wl[3] gnd reram_bitcell_7
Xbit_r4_c102 bl[102] br[102] wl[4] gnd reram_bitcell_7
Xbit_r5_c102 bl[102] br[102] wl[5] gnd reram_bitcell_7
Xbit_r6_c102 bl[102] br[102] wl[6] gnd reram_bitcell_7
Xbit_r7_c102 bl[102] br[102] wl[7] gnd reram_bitcell_7
Xbit_r8_c102 bl[102] br[102] wl[8] gnd reram_bitcell_7
Xbit_r9_c102 bl[102] br[102] wl[9] gnd reram_bitcell_7
Xbit_r10_c102 bl[102] br[102] wl[10] gnd reram_bitcell_7
Xbit_r11_c102 bl[102] br[102] wl[11] gnd reram_bitcell_7
Xbit_r12_c102 bl[102] br[102] wl[12] gnd reram_bitcell_7
Xbit_r13_c102 bl[102] br[102] wl[13] gnd reram_bitcell_7
Xbit_r14_c102 bl[102] br[102] wl[14] gnd reram_bitcell_7
Xbit_r15_c102 bl[102] br[102] wl[15] gnd reram_bitcell_7
Xbit_r16_c102 bl[102] br[102] wl[16] gnd reram_bitcell_7
Xbit_r17_c102 bl[102] br[102] wl[17] gnd reram_bitcell_7
Xbit_r18_c102 bl[102] br[102] wl[18] gnd reram_bitcell_7
Xbit_r19_c102 bl[102] br[102] wl[19] gnd reram_bitcell_7
Xbit_r20_c102 bl[102] br[102] wl[20] gnd reram_bitcell_7
Xbit_r21_c102 bl[102] br[102] wl[21] gnd reram_bitcell_7
Xbit_r22_c102 bl[102] br[102] wl[22] gnd reram_bitcell_7
Xbit_r23_c102 bl[102] br[102] wl[23] gnd reram_bitcell_7
Xbit_r24_c102 bl[102] br[102] wl[24] gnd reram_bitcell_7
Xbit_r25_c102 bl[102] br[102] wl[25] gnd reram_bitcell_7
Xbit_r26_c102 bl[102] br[102] wl[26] gnd reram_bitcell_7
Xbit_r27_c102 bl[102] br[102] wl[27] gnd reram_bitcell_7
Xbit_r28_c102 bl[102] br[102] wl[28] gnd reram_bitcell_7
Xbit_r29_c102 bl[102] br[102] wl[29] gnd reram_bitcell_7
Xbit_r30_c102 bl[102] br[102] wl[30] gnd reram_bitcell_7
Xbit_r31_c102 bl[102] br[102] wl[31] gnd reram_bitcell_7
Xbit_r32_c102 bl[102] br[102] wl[32] gnd reram_bitcell_7
Xbit_r33_c102 bl[102] br[102] wl[33] gnd reram_bitcell_7
Xbit_r34_c102 bl[102] br[102] wl[34] gnd reram_bitcell_7
Xbit_r35_c102 bl[102] br[102] wl[35] gnd reram_bitcell_7
Xbit_r36_c102 bl[102] br[102] wl[36] gnd reram_bitcell_7
Xbit_r37_c102 bl[102] br[102] wl[37] gnd reram_bitcell_7
Xbit_r38_c102 bl[102] br[102] wl[38] gnd reram_bitcell_7
Xbit_r39_c102 bl[102] br[102] wl[39] gnd reram_bitcell_7
Xbit_r40_c102 bl[102] br[102] wl[40] gnd reram_bitcell_7
Xbit_r41_c102 bl[102] br[102] wl[41] gnd reram_bitcell_7
Xbit_r42_c102 bl[102] br[102] wl[42] gnd reram_bitcell_7
Xbit_r43_c102 bl[102] br[102] wl[43] gnd reram_bitcell_7
Xbit_r44_c102 bl[102] br[102] wl[44] gnd reram_bitcell_7
Xbit_r45_c102 bl[102] br[102] wl[45] gnd reram_bitcell_7
Xbit_r46_c102 bl[102] br[102] wl[46] gnd reram_bitcell_7
Xbit_r47_c102 bl[102] br[102] wl[47] gnd reram_bitcell_7
Xbit_r48_c102 bl[102] br[102] wl[48] gnd reram_bitcell_7
Xbit_r49_c102 bl[102] br[102] wl[49] gnd reram_bitcell_7
Xbit_r50_c102 bl[102] br[102] wl[50] gnd reram_bitcell_7
Xbit_r51_c102 bl[102] br[102] wl[51] gnd reram_bitcell_7
Xbit_r52_c102 bl[102] br[102] wl[52] gnd reram_bitcell_7
Xbit_r53_c102 bl[102] br[102] wl[53] gnd reram_bitcell_7
Xbit_r54_c102 bl[102] br[102] wl[54] gnd reram_bitcell_7
Xbit_r55_c102 bl[102] br[102] wl[55] gnd reram_bitcell_7
Xbit_r56_c102 bl[102] br[102] wl[56] gnd reram_bitcell_7
Xbit_r57_c102 bl[102] br[102] wl[57] gnd reram_bitcell_7
Xbit_r58_c102 bl[102] br[102] wl[58] gnd reram_bitcell_7
Xbit_r59_c102 bl[102] br[102] wl[59] gnd reram_bitcell_7
Xbit_r60_c102 bl[102] br[102] wl[60] gnd reram_bitcell_7
Xbit_r61_c102 bl[102] br[102] wl[61] gnd reram_bitcell_7
Xbit_r62_c102 bl[102] br[102] wl[62] gnd reram_bitcell_7
Xbit_r63_c102 bl[102] br[102] wl[63] gnd reram_bitcell_7
Xbit_r0_c103 bl[103] br[103] wl[0] gnd reram_bitcell_7
Xbit_r1_c103 bl[103] br[103] wl[1] gnd reram_bitcell_7
Xbit_r2_c103 bl[103] br[103] wl[2] gnd reram_bitcell_7
Xbit_r3_c103 bl[103] br[103] wl[3] gnd reram_bitcell_7
Xbit_r4_c103 bl[103] br[103] wl[4] gnd reram_bitcell_7
Xbit_r5_c103 bl[103] br[103] wl[5] gnd reram_bitcell_7
Xbit_r6_c103 bl[103] br[103] wl[6] gnd reram_bitcell_7
Xbit_r7_c103 bl[103] br[103] wl[7] gnd reram_bitcell_7
Xbit_r8_c103 bl[103] br[103] wl[8] gnd reram_bitcell_7
Xbit_r9_c103 bl[103] br[103] wl[9] gnd reram_bitcell_7
Xbit_r10_c103 bl[103] br[103] wl[10] gnd reram_bitcell_7
Xbit_r11_c103 bl[103] br[103] wl[11] gnd reram_bitcell_7
Xbit_r12_c103 bl[103] br[103] wl[12] gnd reram_bitcell_7
Xbit_r13_c103 bl[103] br[103] wl[13] gnd reram_bitcell_7
Xbit_r14_c103 bl[103] br[103] wl[14] gnd reram_bitcell_7
Xbit_r15_c103 bl[103] br[103] wl[15] gnd reram_bitcell_7
Xbit_r16_c103 bl[103] br[103] wl[16] gnd reram_bitcell_7
Xbit_r17_c103 bl[103] br[103] wl[17] gnd reram_bitcell_7
Xbit_r18_c103 bl[103] br[103] wl[18] gnd reram_bitcell_7
Xbit_r19_c103 bl[103] br[103] wl[19] gnd reram_bitcell_7
Xbit_r20_c103 bl[103] br[103] wl[20] gnd reram_bitcell_7
Xbit_r21_c103 bl[103] br[103] wl[21] gnd reram_bitcell_7
Xbit_r22_c103 bl[103] br[103] wl[22] gnd reram_bitcell_7
Xbit_r23_c103 bl[103] br[103] wl[23] gnd reram_bitcell_7
Xbit_r24_c103 bl[103] br[103] wl[24] gnd reram_bitcell_7
Xbit_r25_c103 bl[103] br[103] wl[25] gnd reram_bitcell_7
Xbit_r26_c103 bl[103] br[103] wl[26] gnd reram_bitcell_7
Xbit_r27_c103 bl[103] br[103] wl[27] gnd reram_bitcell_7
Xbit_r28_c103 bl[103] br[103] wl[28] gnd reram_bitcell_7
Xbit_r29_c103 bl[103] br[103] wl[29] gnd reram_bitcell_7
Xbit_r30_c103 bl[103] br[103] wl[30] gnd reram_bitcell_7
Xbit_r31_c103 bl[103] br[103] wl[31] gnd reram_bitcell_7
Xbit_r32_c103 bl[103] br[103] wl[32] gnd reram_bitcell_7
Xbit_r33_c103 bl[103] br[103] wl[33] gnd reram_bitcell_7
Xbit_r34_c103 bl[103] br[103] wl[34] gnd reram_bitcell_7
Xbit_r35_c103 bl[103] br[103] wl[35] gnd reram_bitcell_7
Xbit_r36_c103 bl[103] br[103] wl[36] gnd reram_bitcell_7
Xbit_r37_c103 bl[103] br[103] wl[37] gnd reram_bitcell_7
Xbit_r38_c103 bl[103] br[103] wl[38] gnd reram_bitcell_7
Xbit_r39_c103 bl[103] br[103] wl[39] gnd reram_bitcell_7
Xbit_r40_c103 bl[103] br[103] wl[40] gnd reram_bitcell_7
Xbit_r41_c103 bl[103] br[103] wl[41] gnd reram_bitcell_7
Xbit_r42_c103 bl[103] br[103] wl[42] gnd reram_bitcell_7
Xbit_r43_c103 bl[103] br[103] wl[43] gnd reram_bitcell_7
Xbit_r44_c103 bl[103] br[103] wl[44] gnd reram_bitcell_7
Xbit_r45_c103 bl[103] br[103] wl[45] gnd reram_bitcell_7
Xbit_r46_c103 bl[103] br[103] wl[46] gnd reram_bitcell_7
Xbit_r47_c103 bl[103] br[103] wl[47] gnd reram_bitcell_7
Xbit_r48_c103 bl[103] br[103] wl[48] gnd reram_bitcell_7
Xbit_r49_c103 bl[103] br[103] wl[49] gnd reram_bitcell_7
Xbit_r50_c103 bl[103] br[103] wl[50] gnd reram_bitcell_7
Xbit_r51_c103 bl[103] br[103] wl[51] gnd reram_bitcell_7
Xbit_r52_c103 bl[103] br[103] wl[52] gnd reram_bitcell_7
Xbit_r53_c103 bl[103] br[103] wl[53] gnd reram_bitcell_7
Xbit_r54_c103 bl[103] br[103] wl[54] gnd reram_bitcell_7
Xbit_r55_c103 bl[103] br[103] wl[55] gnd reram_bitcell_7
Xbit_r56_c103 bl[103] br[103] wl[56] gnd reram_bitcell_7
Xbit_r57_c103 bl[103] br[103] wl[57] gnd reram_bitcell_7
Xbit_r58_c103 bl[103] br[103] wl[58] gnd reram_bitcell_7
Xbit_r59_c103 bl[103] br[103] wl[59] gnd reram_bitcell_7
Xbit_r60_c103 bl[103] br[103] wl[60] gnd reram_bitcell_7
Xbit_r61_c103 bl[103] br[103] wl[61] gnd reram_bitcell_7
Xbit_r62_c103 bl[103] br[103] wl[62] gnd reram_bitcell_7
Xbit_r63_c103 bl[103] br[103] wl[63] gnd reram_bitcell_7
Xbit_r0_c104 bl[104] br[104] wl[0] gnd reram_bitcell_7
Xbit_r1_c104 bl[104] br[104] wl[1] gnd reram_bitcell_7
Xbit_r2_c104 bl[104] br[104] wl[2] gnd reram_bitcell_7
Xbit_r3_c104 bl[104] br[104] wl[3] gnd reram_bitcell_7
Xbit_r4_c104 bl[104] br[104] wl[4] gnd reram_bitcell_7
Xbit_r5_c104 bl[104] br[104] wl[5] gnd reram_bitcell_7
Xbit_r6_c104 bl[104] br[104] wl[6] gnd reram_bitcell_7
Xbit_r7_c104 bl[104] br[104] wl[7] gnd reram_bitcell_7
Xbit_r8_c104 bl[104] br[104] wl[8] gnd reram_bitcell_7
Xbit_r9_c104 bl[104] br[104] wl[9] gnd reram_bitcell_7
Xbit_r10_c104 bl[104] br[104] wl[10] gnd reram_bitcell_7
Xbit_r11_c104 bl[104] br[104] wl[11] gnd reram_bitcell_7
Xbit_r12_c104 bl[104] br[104] wl[12] gnd reram_bitcell_7
Xbit_r13_c104 bl[104] br[104] wl[13] gnd reram_bitcell_7
Xbit_r14_c104 bl[104] br[104] wl[14] gnd reram_bitcell_7
Xbit_r15_c104 bl[104] br[104] wl[15] gnd reram_bitcell_7
Xbit_r16_c104 bl[104] br[104] wl[16] gnd reram_bitcell_7
Xbit_r17_c104 bl[104] br[104] wl[17] gnd reram_bitcell_7
Xbit_r18_c104 bl[104] br[104] wl[18] gnd reram_bitcell_7
Xbit_r19_c104 bl[104] br[104] wl[19] gnd reram_bitcell_7
Xbit_r20_c104 bl[104] br[104] wl[20] gnd reram_bitcell_7
Xbit_r21_c104 bl[104] br[104] wl[21] gnd reram_bitcell_7
Xbit_r22_c104 bl[104] br[104] wl[22] gnd reram_bitcell_7
Xbit_r23_c104 bl[104] br[104] wl[23] gnd reram_bitcell_7
Xbit_r24_c104 bl[104] br[104] wl[24] gnd reram_bitcell_7
Xbit_r25_c104 bl[104] br[104] wl[25] gnd reram_bitcell_7
Xbit_r26_c104 bl[104] br[104] wl[26] gnd reram_bitcell_7
Xbit_r27_c104 bl[104] br[104] wl[27] gnd reram_bitcell_7
Xbit_r28_c104 bl[104] br[104] wl[28] gnd reram_bitcell_7
Xbit_r29_c104 bl[104] br[104] wl[29] gnd reram_bitcell_7
Xbit_r30_c104 bl[104] br[104] wl[30] gnd reram_bitcell_7
Xbit_r31_c104 bl[104] br[104] wl[31] gnd reram_bitcell_7
Xbit_r32_c104 bl[104] br[104] wl[32] gnd reram_bitcell_7
Xbit_r33_c104 bl[104] br[104] wl[33] gnd reram_bitcell_7
Xbit_r34_c104 bl[104] br[104] wl[34] gnd reram_bitcell_7
Xbit_r35_c104 bl[104] br[104] wl[35] gnd reram_bitcell_7
Xbit_r36_c104 bl[104] br[104] wl[36] gnd reram_bitcell_7
Xbit_r37_c104 bl[104] br[104] wl[37] gnd reram_bitcell_7
Xbit_r38_c104 bl[104] br[104] wl[38] gnd reram_bitcell_7
Xbit_r39_c104 bl[104] br[104] wl[39] gnd reram_bitcell_7
Xbit_r40_c104 bl[104] br[104] wl[40] gnd reram_bitcell_7
Xbit_r41_c104 bl[104] br[104] wl[41] gnd reram_bitcell_7
Xbit_r42_c104 bl[104] br[104] wl[42] gnd reram_bitcell_7
Xbit_r43_c104 bl[104] br[104] wl[43] gnd reram_bitcell_7
Xbit_r44_c104 bl[104] br[104] wl[44] gnd reram_bitcell_7
Xbit_r45_c104 bl[104] br[104] wl[45] gnd reram_bitcell_7
Xbit_r46_c104 bl[104] br[104] wl[46] gnd reram_bitcell_7
Xbit_r47_c104 bl[104] br[104] wl[47] gnd reram_bitcell_7
Xbit_r48_c104 bl[104] br[104] wl[48] gnd reram_bitcell_7
Xbit_r49_c104 bl[104] br[104] wl[49] gnd reram_bitcell_7
Xbit_r50_c104 bl[104] br[104] wl[50] gnd reram_bitcell_7
Xbit_r51_c104 bl[104] br[104] wl[51] gnd reram_bitcell_7
Xbit_r52_c104 bl[104] br[104] wl[52] gnd reram_bitcell_7
Xbit_r53_c104 bl[104] br[104] wl[53] gnd reram_bitcell_7
Xbit_r54_c104 bl[104] br[104] wl[54] gnd reram_bitcell_7
Xbit_r55_c104 bl[104] br[104] wl[55] gnd reram_bitcell_7
Xbit_r56_c104 bl[104] br[104] wl[56] gnd reram_bitcell_7
Xbit_r57_c104 bl[104] br[104] wl[57] gnd reram_bitcell_7
Xbit_r58_c104 bl[104] br[104] wl[58] gnd reram_bitcell_7
Xbit_r59_c104 bl[104] br[104] wl[59] gnd reram_bitcell_7
Xbit_r60_c104 bl[104] br[104] wl[60] gnd reram_bitcell_7
Xbit_r61_c104 bl[104] br[104] wl[61] gnd reram_bitcell_7
Xbit_r62_c104 bl[104] br[104] wl[62] gnd reram_bitcell_7
Xbit_r63_c104 bl[104] br[104] wl[63] gnd reram_bitcell_7
Xbit_r0_c105 bl[105] br[105] wl[0] gnd reram_bitcell_7
Xbit_r1_c105 bl[105] br[105] wl[1] gnd reram_bitcell_7
Xbit_r2_c105 bl[105] br[105] wl[2] gnd reram_bitcell_7
Xbit_r3_c105 bl[105] br[105] wl[3] gnd reram_bitcell_7
Xbit_r4_c105 bl[105] br[105] wl[4] gnd reram_bitcell_7
Xbit_r5_c105 bl[105] br[105] wl[5] gnd reram_bitcell_7
Xbit_r6_c105 bl[105] br[105] wl[6] gnd reram_bitcell_7
Xbit_r7_c105 bl[105] br[105] wl[7] gnd reram_bitcell_7
Xbit_r8_c105 bl[105] br[105] wl[8] gnd reram_bitcell_7
Xbit_r9_c105 bl[105] br[105] wl[9] gnd reram_bitcell_7
Xbit_r10_c105 bl[105] br[105] wl[10] gnd reram_bitcell_7
Xbit_r11_c105 bl[105] br[105] wl[11] gnd reram_bitcell_7
Xbit_r12_c105 bl[105] br[105] wl[12] gnd reram_bitcell_7
Xbit_r13_c105 bl[105] br[105] wl[13] gnd reram_bitcell_7
Xbit_r14_c105 bl[105] br[105] wl[14] gnd reram_bitcell_7
Xbit_r15_c105 bl[105] br[105] wl[15] gnd reram_bitcell_7
Xbit_r16_c105 bl[105] br[105] wl[16] gnd reram_bitcell_7
Xbit_r17_c105 bl[105] br[105] wl[17] gnd reram_bitcell_7
Xbit_r18_c105 bl[105] br[105] wl[18] gnd reram_bitcell_7
Xbit_r19_c105 bl[105] br[105] wl[19] gnd reram_bitcell_7
Xbit_r20_c105 bl[105] br[105] wl[20] gnd reram_bitcell_7
Xbit_r21_c105 bl[105] br[105] wl[21] gnd reram_bitcell_7
Xbit_r22_c105 bl[105] br[105] wl[22] gnd reram_bitcell_7
Xbit_r23_c105 bl[105] br[105] wl[23] gnd reram_bitcell_7
Xbit_r24_c105 bl[105] br[105] wl[24] gnd reram_bitcell_7
Xbit_r25_c105 bl[105] br[105] wl[25] gnd reram_bitcell_7
Xbit_r26_c105 bl[105] br[105] wl[26] gnd reram_bitcell_7
Xbit_r27_c105 bl[105] br[105] wl[27] gnd reram_bitcell_7
Xbit_r28_c105 bl[105] br[105] wl[28] gnd reram_bitcell_7
Xbit_r29_c105 bl[105] br[105] wl[29] gnd reram_bitcell_7
Xbit_r30_c105 bl[105] br[105] wl[30] gnd reram_bitcell_7
Xbit_r31_c105 bl[105] br[105] wl[31] gnd reram_bitcell_7
Xbit_r32_c105 bl[105] br[105] wl[32] gnd reram_bitcell_7
Xbit_r33_c105 bl[105] br[105] wl[33] gnd reram_bitcell_7
Xbit_r34_c105 bl[105] br[105] wl[34] gnd reram_bitcell_7
Xbit_r35_c105 bl[105] br[105] wl[35] gnd reram_bitcell_7
Xbit_r36_c105 bl[105] br[105] wl[36] gnd reram_bitcell_7
Xbit_r37_c105 bl[105] br[105] wl[37] gnd reram_bitcell_7
Xbit_r38_c105 bl[105] br[105] wl[38] gnd reram_bitcell_7
Xbit_r39_c105 bl[105] br[105] wl[39] gnd reram_bitcell_7
Xbit_r40_c105 bl[105] br[105] wl[40] gnd reram_bitcell_7
Xbit_r41_c105 bl[105] br[105] wl[41] gnd reram_bitcell_7
Xbit_r42_c105 bl[105] br[105] wl[42] gnd reram_bitcell_7
Xbit_r43_c105 bl[105] br[105] wl[43] gnd reram_bitcell_7
Xbit_r44_c105 bl[105] br[105] wl[44] gnd reram_bitcell_7
Xbit_r45_c105 bl[105] br[105] wl[45] gnd reram_bitcell_7
Xbit_r46_c105 bl[105] br[105] wl[46] gnd reram_bitcell_7
Xbit_r47_c105 bl[105] br[105] wl[47] gnd reram_bitcell_7
Xbit_r48_c105 bl[105] br[105] wl[48] gnd reram_bitcell_7
Xbit_r49_c105 bl[105] br[105] wl[49] gnd reram_bitcell_7
Xbit_r50_c105 bl[105] br[105] wl[50] gnd reram_bitcell_7
Xbit_r51_c105 bl[105] br[105] wl[51] gnd reram_bitcell_7
Xbit_r52_c105 bl[105] br[105] wl[52] gnd reram_bitcell_7
Xbit_r53_c105 bl[105] br[105] wl[53] gnd reram_bitcell_7
Xbit_r54_c105 bl[105] br[105] wl[54] gnd reram_bitcell_7
Xbit_r55_c105 bl[105] br[105] wl[55] gnd reram_bitcell_7
Xbit_r56_c105 bl[105] br[105] wl[56] gnd reram_bitcell_7
Xbit_r57_c105 bl[105] br[105] wl[57] gnd reram_bitcell_7
Xbit_r58_c105 bl[105] br[105] wl[58] gnd reram_bitcell_7
Xbit_r59_c105 bl[105] br[105] wl[59] gnd reram_bitcell_7
Xbit_r60_c105 bl[105] br[105] wl[60] gnd reram_bitcell_7
Xbit_r61_c105 bl[105] br[105] wl[61] gnd reram_bitcell_7
Xbit_r62_c105 bl[105] br[105] wl[62] gnd reram_bitcell_7
Xbit_r63_c105 bl[105] br[105] wl[63] gnd reram_bitcell_7
Xbit_r0_c106 bl[106] br[106] wl[0] gnd reram_bitcell_7
Xbit_r1_c106 bl[106] br[106] wl[1] gnd reram_bitcell_7
Xbit_r2_c106 bl[106] br[106] wl[2] gnd reram_bitcell_7
Xbit_r3_c106 bl[106] br[106] wl[3] gnd reram_bitcell_7
Xbit_r4_c106 bl[106] br[106] wl[4] gnd reram_bitcell_7
Xbit_r5_c106 bl[106] br[106] wl[5] gnd reram_bitcell_7
Xbit_r6_c106 bl[106] br[106] wl[6] gnd reram_bitcell_7
Xbit_r7_c106 bl[106] br[106] wl[7] gnd reram_bitcell_7
Xbit_r8_c106 bl[106] br[106] wl[8] gnd reram_bitcell_7
Xbit_r9_c106 bl[106] br[106] wl[9] gnd reram_bitcell_7
Xbit_r10_c106 bl[106] br[106] wl[10] gnd reram_bitcell_7
Xbit_r11_c106 bl[106] br[106] wl[11] gnd reram_bitcell_7
Xbit_r12_c106 bl[106] br[106] wl[12] gnd reram_bitcell_7
Xbit_r13_c106 bl[106] br[106] wl[13] gnd reram_bitcell_7
Xbit_r14_c106 bl[106] br[106] wl[14] gnd reram_bitcell_7
Xbit_r15_c106 bl[106] br[106] wl[15] gnd reram_bitcell_7
Xbit_r16_c106 bl[106] br[106] wl[16] gnd reram_bitcell_7
Xbit_r17_c106 bl[106] br[106] wl[17] gnd reram_bitcell_7
Xbit_r18_c106 bl[106] br[106] wl[18] gnd reram_bitcell_7
Xbit_r19_c106 bl[106] br[106] wl[19] gnd reram_bitcell_7
Xbit_r20_c106 bl[106] br[106] wl[20] gnd reram_bitcell_7
Xbit_r21_c106 bl[106] br[106] wl[21] gnd reram_bitcell_7
Xbit_r22_c106 bl[106] br[106] wl[22] gnd reram_bitcell_7
Xbit_r23_c106 bl[106] br[106] wl[23] gnd reram_bitcell_7
Xbit_r24_c106 bl[106] br[106] wl[24] gnd reram_bitcell_7
Xbit_r25_c106 bl[106] br[106] wl[25] gnd reram_bitcell_7
Xbit_r26_c106 bl[106] br[106] wl[26] gnd reram_bitcell_7
Xbit_r27_c106 bl[106] br[106] wl[27] gnd reram_bitcell_7
Xbit_r28_c106 bl[106] br[106] wl[28] gnd reram_bitcell_7
Xbit_r29_c106 bl[106] br[106] wl[29] gnd reram_bitcell_7
Xbit_r30_c106 bl[106] br[106] wl[30] gnd reram_bitcell_7
Xbit_r31_c106 bl[106] br[106] wl[31] gnd reram_bitcell_7
Xbit_r32_c106 bl[106] br[106] wl[32] gnd reram_bitcell_7
Xbit_r33_c106 bl[106] br[106] wl[33] gnd reram_bitcell_7
Xbit_r34_c106 bl[106] br[106] wl[34] gnd reram_bitcell_7
Xbit_r35_c106 bl[106] br[106] wl[35] gnd reram_bitcell_7
Xbit_r36_c106 bl[106] br[106] wl[36] gnd reram_bitcell_7
Xbit_r37_c106 bl[106] br[106] wl[37] gnd reram_bitcell_7
Xbit_r38_c106 bl[106] br[106] wl[38] gnd reram_bitcell_7
Xbit_r39_c106 bl[106] br[106] wl[39] gnd reram_bitcell_7
Xbit_r40_c106 bl[106] br[106] wl[40] gnd reram_bitcell_7
Xbit_r41_c106 bl[106] br[106] wl[41] gnd reram_bitcell_7
Xbit_r42_c106 bl[106] br[106] wl[42] gnd reram_bitcell_7
Xbit_r43_c106 bl[106] br[106] wl[43] gnd reram_bitcell_7
Xbit_r44_c106 bl[106] br[106] wl[44] gnd reram_bitcell_7
Xbit_r45_c106 bl[106] br[106] wl[45] gnd reram_bitcell_7
Xbit_r46_c106 bl[106] br[106] wl[46] gnd reram_bitcell_7
Xbit_r47_c106 bl[106] br[106] wl[47] gnd reram_bitcell_7
Xbit_r48_c106 bl[106] br[106] wl[48] gnd reram_bitcell_7
Xbit_r49_c106 bl[106] br[106] wl[49] gnd reram_bitcell_7
Xbit_r50_c106 bl[106] br[106] wl[50] gnd reram_bitcell_7
Xbit_r51_c106 bl[106] br[106] wl[51] gnd reram_bitcell_7
Xbit_r52_c106 bl[106] br[106] wl[52] gnd reram_bitcell_7
Xbit_r53_c106 bl[106] br[106] wl[53] gnd reram_bitcell_7
Xbit_r54_c106 bl[106] br[106] wl[54] gnd reram_bitcell_7
Xbit_r55_c106 bl[106] br[106] wl[55] gnd reram_bitcell_7
Xbit_r56_c106 bl[106] br[106] wl[56] gnd reram_bitcell_7
Xbit_r57_c106 bl[106] br[106] wl[57] gnd reram_bitcell_7
Xbit_r58_c106 bl[106] br[106] wl[58] gnd reram_bitcell_7
Xbit_r59_c106 bl[106] br[106] wl[59] gnd reram_bitcell_7
Xbit_r60_c106 bl[106] br[106] wl[60] gnd reram_bitcell_7
Xbit_r61_c106 bl[106] br[106] wl[61] gnd reram_bitcell_7
Xbit_r62_c106 bl[106] br[106] wl[62] gnd reram_bitcell_7
Xbit_r63_c106 bl[106] br[106] wl[63] gnd reram_bitcell_7
Xbit_r0_c107 bl[107] br[107] wl[0] gnd reram_bitcell_7
Xbit_r1_c107 bl[107] br[107] wl[1] gnd reram_bitcell_7
Xbit_r2_c107 bl[107] br[107] wl[2] gnd reram_bitcell_7
Xbit_r3_c107 bl[107] br[107] wl[3] gnd reram_bitcell_7
Xbit_r4_c107 bl[107] br[107] wl[4] gnd reram_bitcell_7
Xbit_r5_c107 bl[107] br[107] wl[5] gnd reram_bitcell_7
Xbit_r6_c107 bl[107] br[107] wl[6] gnd reram_bitcell_7
Xbit_r7_c107 bl[107] br[107] wl[7] gnd reram_bitcell_7
Xbit_r8_c107 bl[107] br[107] wl[8] gnd reram_bitcell_7
Xbit_r9_c107 bl[107] br[107] wl[9] gnd reram_bitcell_7
Xbit_r10_c107 bl[107] br[107] wl[10] gnd reram_bitcell_7
Xbit_r11_c107 bl[107] br[107] wl[11] gnd reram_bitcell_7
Xbit_r12_c107 bl[107] br[107] wl[12] gnd reram_bitcell_7
Xbit_r13_c107 bl[107] br[107] wl[13] gnd reram_bitcell_7
Xbit_r14_c107 bl[107] br[107] wl[14] gnd reram_bitcell_7
Xbit_r15_c107 bl[107] br[107] wl[15] gnd reram_bitcell_7
Xbit_r16_c107 bl[107] br[107] wl[16] gnd reram_bitcell_7
Xbit_r17_c107 bl[107] br[107] wl[17] gnd reram_bitcell_7
Xbit_r18_c107 bl[107] br[107] wl[18] gnd reram_bitcell_7
Xbit_r19_c107 bl[107] br[107] wl[19] gnd reram_bitcell_7
Xbit_r20_c107 bl[107] br[107] wl[20] gnd reram_bitcell_7
Xbit_r21_c107 bl[107] br[107] wl[21] gnd reram_bitcell_7
Xbit_r22_c107 bl[107] br[107] wl[22] gnd reram_bitcell_7
Xbit_r23_c107 bl[107] br[107] wl[23] gnd reram_bitcell_7
Xbit_r24_c107 bl[107] br[107] wl[24] gnd reram_bitcell_7
Xbit_r25_c107 bl[107] br[107] wl[25] gnd reram_bitcell_7
Xbit_r26_c107 bl[107] br[107] wl[26] gnd reram_bitcell_7
Xbit_r27_c107 bl[107] br[107] wl[27] gnd reram_bitcell_7
Xbit_r28_c107 bl[107] br[107] wl[28] gnd reram_bitcell_7
Xbit_r29_c107 bl[107] br[107] wl[29] gnd reram_bitcell_7
Xbit_r30_c107 bl[107] br[107] wl[30] gnd reram_bitcell_7
Xbit_r31_c107 bl[107] br[107] wl[31] gnd reram_bitcell_7
Xbit_r32_c107 bl[107] br[107] wl[32] gnd reram_bitcell_7
Xbit_r33_c107 bl[107] br[107] wl[33] gnd reram_bitcell_7
Xbit_r34_c107 bl[107] br[107] wl[34] gnd reram_bitcell_7
Xbit_r35_c107 bl[107] br[107] wl[35] gnd reram_bitcell_7
Xbit_r36_c107 bl[107] br[107] wl[36] gnd reram_bitcell_7
Xbit_r37_c107 bl[107] br[107] wl[37] gnd reram_bitcell_7
Xbit_r38_c107 bl[107] br[107] wl[38] gnd reram_bitcell_7
Xbit_r39_c107 bl[107] br[107] wl[39] gnd reram_bitcell_7
Xbit_r40_c107 bl[107] br[107] wl[40] gnd reram_bitcell_7
Xbit_r41_c107 bl[107] br[107] wl[41] gnd reram_bitcell_7
Xbit_r42_c107 bl[107] br[107] wl[42] gnd reram_bitcell_7
Xbit_r43_c107 bl[107] br[107] wl[43] gnd reram_bitcell_7
Xbit_r44_c107 bl[107] br[107] wl[44] gnd reram_bitcell_7
Xbit_r45_c107 bl[107] br[107] wl[45] gnd reram_bitcell_7
Xbit_r46_c107 bl[107] br[107] wl[46] gnd reram_bitcell_7
Xbit_r47_c107 bl[107] br[107] wl[47] gnd reram_bitcell_7
Xbit_r48_c107 bl[107] br[107] wl[48] gnd reram_bitcell_7
Xbit_r49_c107 bl[107] br[107] wl[49] gnd reram_bitcell_7
Xbit_r50_c107 bl[107] br[107] wl[50] gnd reram_bitcell_7
Xbit_r51_c107 bl[107] br[107] wl[51] gnd reram_bitcell_7
Xbit_r52_c107 bl[107] br[107] wl[52] gnd reram_bitcell_7
Xbit_r53_c107 bl[107] br[107] wl[53] gnd reram_bitcell_7
Xbit_r54_c107 bl[107] br[107] wl[54] gnd reram_bitcell_7
Xbit_r55_c107 bl[107] br[107] wl[55] gnd reram_bitcell_7
Xbit_r56_c107 bl[107] br[107] wl[56] gnd reram_bitcell_7
Xbit_r57_c107 bl[107] br[107] wl[57] gnd reram_bitcell_7
Xbit_r58_c107 bl[107] br[107] wl[58] gnd reram_bitcell_7
Xbit_r59_c107 bl[107] br[107] wl[59] gnd reram_bitcell_7
Xbit_r60_c107 bl[107] br[107] wl[60] gnd reram_bitcell_7
Xbit_r61_c107 bl[107] br[107] wl[61] gnd reram_bitcell_7
Xbit_r62_c107 bl[107] br[107] wl[62] gnd reram_bitcell_7
Xbit_r63_c107 bl[107] br[107] wl[63] gnd reram_bitcell_7
Xbit_r0_c108 bl[108] br[108] wl[0] gnd reram_bitcell_7
Xbit_r1_c108 bl[108] br[108] wl[1] gnd reram_bitcell_7
Xbit_r2_c108 bl[108] br[108] wl[2] gnd reram_bitcell_7
Xbit_r3_c108 bl[108] br[108] wl[3] gnd reram_bitcell_7
Xbit_r4_c108 bl[108] br[108] wl[4] gnd reram_bitcell_7
Xbit_r5_c108 bl[108] br[108] wl[5] gnd reram_bitcell_7
Xbit_r6_c108 bl[108] br[108] wl[6] gnd reram_bitcell_7
Xbit_r7_c108 bl[108] br[108] wl[7] gnd reram_bitcell_7
Xbit_r8_c108 bl[108] br[108] wl[8] gnd reram_bitcell_7
Xbit_r9_c108 bl[108] br[108] wl[9] gnd reram_bitcell_7
Xbit_r10_c108 bl[108] br[108] wl[10] gnd reram_bitcell_7
Xbit_r11_c108 bl[108] br[108] wl[11] gnd reram_bitcell_7
Xbit_r12_c108 bl[108] br[108] wl[12] gnd reram_bitcell_7
Xbit_r13_c108 bl[108] br[108] wl[13] gnd reram_bitcell_7
Xbit_r14_c108 bl[108] br[108] wl[14] gnd reram_bitcell_7
Xbit_r15_c108 bl[108] br[108] wl[15] gnd reram_bitcell_7
Xbit_r16_c108 bl[108] br[108] wl[16] gnd reram_bitcell_7
Xbit_r17_c108 bl[108] br[108] wl[17] gnd reram_bitcell_7
Xbit_r18_c108 bl[108] br[108] wl[18] gnd reram_bitcell_7
Xbit_r19_c108 bl[108] br[108] wl[19] gnd reram_bitcell_7
Xbit_r20_c108 bl[108] br[108] wl[20] gnd reram_bitcell_7
Xbit_r21_c108 bl[108] br[108] wl[21] gnd reram_bitcell_7
Xbit_r22_c108 bl[108] br[108] wl[22] gnd reram_bitcell_7
Xbit_r23_c108 bl[108] br[108] wl[23] gnd reram_bitcell_7
Xbit_r24_c108 bl[108] br[108] wl[24] gnd reram_bitcell_7
Xbit_r25_c108 bl[108] br[108] wl[25] gnd reram_bitcell_7
Xbit_r26_c108 bl[108] br[108] wl[26] gnd reram_bitcell_7
Xbit_r27_c108 bl[108] br[108] wl[27] gnd reram_bitcell_7
Xbit_r28_c108 bl[108] br[108] wl[28] gnd reram_bitcell_7
Xbit_r29_c108 bl[108] br[108] wl[29] gnd reram_bitcell_7
Xbit_r30_c108 bl[108] br[108] wl[30] gnd reram_bitcell_7
Xbit_r31_c108 bl[108] br[108] wl[31] gnd reram_bitcell_7
Xbit_r32_c108 bl[108] br[108] wl[32] gnd reram_bitcell_7
Xbit_r33_c108 bl[108] br[108] wl[33] gnd reram_bitcell_7
Xbit_r34_c108 bl[108] br[108] wl[34] gnd reram_bitcell_7
Xbit_r35_c108 bl[108] br[108] wl[35] gnd reram_bitcell_7
Xbit_r36_c108 bl[108] br[108] wl[36] gnd reram_bitcell_7
Xbit_r37_c108 bl[108] br[108] wl[37] gnd reram_bitcell_7
Xbit_r38_c108 bl[108] br[108] wl[38] gnd reram_bitcell_7
Xbit_r39_c108 bl[108] br[108] wl[39] gnd reram_bitcell_7
Xbit_r40_c108 bl[108] br[108] wl[40] gnd reram_bitcell_7
Xbit_r41_c108 bl[108] br[108] wl[41] gnd reram_bitcell_7
Xbit_r42_c108 bl[108] br[108] wl[42] gnd reram_bitcell_7
Xbit_r43_c108 bl[108] br[108] wl[43] gnd reram_bitcell_7
Xbit_r44_c108 bl[108] br[108] wl[44] gnd reram_bitcell_7
Xbit_r45_c108 bl[108] br[108] wl[45] gnd reram_bitcell_7
Xbit_r46_c108 bl[108] br[108] wl[46] gnd reram_bitcell_7
Xbit_r47_c108 bl[108] br[108] wl[47] gnd reram_bitcell_7
Xbit_r48_c108 bl[108] br[108] wl[48] gnd reram_bitcell_7
Xbit_r49_c108 bl[108] br[108] wl[49] gnd reram_bitcell_7
Xbit_r50_c108 bl[108] br[108] wl[50] gnd reram_bitcell_7
Xbit_r51_c108 bl[108] br[108] wl[51] gnd reram_bitcell_7
Xbit_r52_c108 bl[108] br[108] wl[52] gnd reram_bitcell_7
Xbit_r53_c108 bl[108] br[108] wl[53] gnd reram_bitcell_7
Xbit_r54_c108 bl[108] br[108] wl[54] gnd reram_bitcell_7
Xbit_r55_c108 bl[108] br[108] wl[55] gnd reram_bitcell_7
Xbit_r56_c108 bl[108] br[108] wl[56] gnd reram_bitcell_7
Xbit_r57_c108 bl[108] br[108] wl[57] gnd reram_bitcell_7
Xbit_r58_c108 bl[108] br[108] wl[58] gnd reram_bitcell_7
Xbit_r59_c108 bl[108] br[108] wl[59] gnd reram_bitcell_7
Xbit_r60_c108 bl[108] br[108] wl[60] gnd reram_bitcell_7
Xbit_r61_c108 bl[108] br[108] wl[61] gnd reram_bitcell_7
Xbit_r62_c108 bl[108] br[108] wl[62] gnd reram_bitcell_7
Xbit_r63_c108 bl[108] br[108] wl[63] gnd reram_bitcell_7
Xbit_r0_c109 bl[109] br[109] wl[0] gnd reram_bitcell_7
Xbit_r1_c109 bl[109] br[109] wl[1] gnd reram_bitcell_7
Xbit_r2_c109 bl[109] br[109] wl[2] gnd reram_bitcell_7
Xbit_r3_c109 bl[109] br[109] wl[3] gnd reram_bitcell_7
Xbit_r4_c109 bl[109] br[109] wl[4] gnd reram_bitcell_7
Xbit_r5_c109 bl[109] br[109] wl[5] gnd reram_bitcell_7
Xbit_r6_c109 bl[109] br[109] wl[6] gnd reram_bitcell_7
Xbit_r7_c109 bl[109] br[109] wl[7] gnd reram_bitcell_7
Xbit_r8_c109 bl[109] br[109] wl[8] gnd reram_bitcell_7
Xbit_r9_c109 bl[109] br[109] wl[9] gnd reram_bitcell_7
Xbit_r10_c109 bl[109] br[109] wl[10] gnd reram_bitcell_7
Xbit_r11_c109 bl[109] br[109] wl[11] gnd reram_bitcell_7
Xbit_r12_c109 bl[109] br[109] wl[12] gnd reram_bitcell_7
Xbit_r13_c109 bl[109] br[109] wl[13] gnd reram_bitcell_7
Xbit_r14_c109 bl[109] br[109] wl[14] gnd reram_bitcell_7
Xbit_r15_c109 bl[109] br[109] wl[15] gnd reram_bitcell_7
Xbit_r16_c109 bl[109] br[109] wl[16] gnd reram_bitcell_7
Xbit_r17_c109 bl[109] br[109] wl[17] gnd reram_bitcell_7
Xbit_r18_c109 bl[109] br[109] wl[18] gnd reram_bitcell_7
Xbit_r19_c109 bl[109] br[109] wl[19] gnd reram_bitcell_7
Xbit_r20_c109 bl[109] br[109] wl[20] gnd reram_bitcell_7
Xbit_r21_c109 bl[109] br[109] wl[21] gnd reram_bitcell_7
Xbit_r22_c109 bl[109] br[109] wl[22] gnd reram_bitcell_7
Xbit_r23_c109 bl[109] br[109] wl[23] gnd reram_bitcell_7
Xbit_r24_c109 bl[109] br[109] wl[24] gnd reram_bitcell_7
Xbit_r25_c109 bl[109] br[109] wl[25] gnd reram_bitcell_7
Xbit_r26_c109 bl[109] br[109] wl[26] gnd reram_bitcell_7
Xbit_r27_c109 bl[109] br[109] wl[27] gnd reram_bitcell_7
Xbit_r28_c109 bl[109] br[109] wl[28] gnd reram_bitcell_7
Xbit_r29_c109 bl[109] br[109] wl[29] gnd reram_bitcell_7
Xbit_r30_c109 bl[109] br[109] wl[30] gnd reram_bitcell_7
Xbit_r31_c109 bl[109] br[109] wl[31] gnd reram_bitcell_7
Xbit_r32_c109 bl[109] br[109] wl[32] gnd reram_bitcell_7
Xbit_r33_c109 bl[109] br[109] wl[33] gnd reram_bitcell_7
Xbit_r34_c109 bl[109] br[109] wl[34] gnd reram_bitcell_7
Xbit_r35_c109 bl[109] br[109] wl[35] gnd reram_bitcell_7
Xbit_r36_c109 bl[109] br[109] wl[36] gnd reram_bitcell_7
Xbit_r37_c109 bl[109] br[109] wl[37] gnd reram_bitcell_7
Xbit_r38_c109 bl[109] br[109] wl[38] gnd reram_bitcell_7
Xbit_r39_c109 bl[109] br[109] wl[39] gnd reram_bitcell_7
Xbit_r40_c109 bl[109] br[109] wl[40] gnd reram_bitcell_7
Xbit_r41_c109 bl[109] br[109] wl[41] gnd reram_bitcell_7
Xbit_r42_c109 bl[109] br[109] wl[42] gnd reram_bitcell_7
Xbit_r43_c109 bl[109] br[109] wl[43] gnd reram_bitcell_7
Xbit_r44_c109 bl[109] br[109] wl[44] gnd reram_bitcell_7
Xbit_r45_c109 bl[109] br[109] wl[45] gnd reram_bitcell_7
Xbit_r46_c109 bl[109] br[109] wl[46] gnd reram_bitcell_7
Xbit_r47_c109 bl[109] br[109] wl[47] gnd reram_bitcell_7
Xbit_r48_c109 bl[109] br[109] wl[48] gnd reram_bitcell_7
Xbit_r49_c109 bl[109] br[109] wl[49] gnd reram_bitcell_7
Xbit_r50_c109 bl[109] br[109] wl[50] gnd reram_bitcell_7
Xbit_r51_c109 bl[109] br[109] wl[51] gnd reram_bitcell_7
Xbit_r52_c109 bl[109] br[109] wl[52] gnd reram_bitcell_7
Xbit_r53_c109 bl[109] br[109] wl[53] gnd reram_bitcell_7
Xbit_r54_c109 bl[109] br[109] wl[54] gnd reram_bitcell_7
Xbit_r55_c109 bl[109] br[109] wl[55] gnd reram_bitcell_7
Xbit_r56_c109 bl[109] br[109] wl[56] gnd reram_bitcell_7
Xbit_r57_c109 bl[109] br[109] wl[57] gnd reram_bitcell_7
Xbit_r58_c109 bl[109] br[109] wl[58] gnd reram_bitcell_7
Xbit_r59_c109 bl[109] br[109] wl[59] gnd reram_bitcell_7
Xbit_r60_c109 bl[109] br[109] wl[60] gnd reram_bitcell_7
Xbit_r61_c109 bl[109] br[109] wl[61] gnd reram_bitcell_7
Xbit_r62_c109 bl[109] br[109] wl[62] gnd reram_bitcell_7
Xbit_r63_c109 bl[109] br[109] wl[63] gnd reram_bitcell_7
Xbit_r0_c110 bl[110] br[110] wl[0] gnd reram_bitcell_7
Xbit_r1_c110 bl[110] br[110] wl[1] gnd reram_bitcell_7
Xbit_r2_c110 bl[110] br[110] wl[2] gnd reram_bitcell_7
Xbit_r3_c110 bl[110] br[110] wl[3] gnd reram_bitcell_7
Xbit_r4_c110 bl[110] br[110] wl[4] gnd reram_bitcell_7
Xbit_r5_c110 bl[110] br[110] wl[5] gnd reram_bitcell_7
Xbit_r6_c110 bl[110] br[110] wl[6] gnd reram_bitcell_7
Xbit_r7_c110 bl[110] br[110] wl[7] gnd reram_bitcell_7
Xbit_r8_c110 bl[110] br[110] wl[8] gnd reram_bitcell_7
Xbit_r9_c110 bl[110] br[110] wl[9] gnd reram_bitcell_7
Xbit_r10_c110 bl[110] br[110] wl[10] gnd reram_bitcell_7
Xbit_r11_c110 bl[110] br[110] wl[11] gnd reram_bitcell_7
Xbit_r12_c110 bl[110] br[110] wl[12] gnd reram_bitcell_7
Xbit_r13_c110 bl[110] br[110] wl[13] gnd reram_bitcell_7
Xbit_r14_c110 bl[110] br[110] wl[14] gnd reram_bitcell_7
Xbit_r15_c110 bl[110] br[110] wl[15] gnd reram_bitcell_7
Xbit_r16_c110 bl[110] br[110] wl[16] gnd reram_bitcell_7
Xbit_r17_c110 bl[110] br[110] wl[17] gnd reram_bitcell_7
Xbit_r18_c110 bl[110] br[110] wl[18] gnd reram_bitcell_7
Xbit_r19_c110 bl[110] br[110] wl[19] gnd reram_bitcell_7
Xbit_r20_c110 bl[110] br[110] wl[20] gnd reram_bitcell_7
Xbit_r21_c110 bl[110] br[110] wl[21] gnd reram_bitcell_7
Xbit_r22_c110 bl[110] br[110] wl[22] gnd reram_bitcell_7
Xbit_r23_c110 bl[110] br[110] wl[23] gnd reram_bitcell_7
Xbit_r24_c110 bl[110] br[110] wl[24] gnd reram_bitcell_7
Xbit_r25_c110 bl[110] br[110] wl[25] gnd reram_bitcell_7
Xbit_r26_c110 bl[110] br[110] wl[26] gnd reram_bitcell_7
Xbit_r27_c110 bl[110] br[110] wl[27] gnd reram_bitcell_7
Xbit_r28_c110 bl[110] br[110] wl[28] gnd reram_bitcell_7
Xbit_r29_c110 bl[110] br[110] wl[29] gnd reram_bitcell_7
Xbit_r30_c110 bl[110] br[110] wl[30] gnd reram_bitcell_7
Xbit_r31_c110 bl[110] br[110] wl[31] gnd reram_bitcell_7
Xbit_r32_c110 bl[110] br[110] wl[32] gnd reram_bitcell_7
Xbit_r33_c110 bl[110] br[110] wl[33] gnd reram_bitcell_7
Xbit_r34_c110 bl[110] br[110] wl[34] gnd reram_bitcell_7
Xbit_r35_c110 bl[110] br[110] wl[35] gnd reram_bitcell_7
Xbit_r36_c110 bl[110] br[110] wl[36] gnd reram_bitcell_7
Xbit_r37_c110 bl[110] br[110] wl[37] gnd reram_bitcell_7
Xbit_r38_c110 bl[110] br[110] wl[38] gnd reram_bitcell_7
Xbit_r39_c110 bl[110] br[110] wl[39] gnd reram_bitcell_7
Xbit_r40_c110 bl[110] br[110] wl[40] gnd reram_bitcell_7
Xbit_r41_c110 bl[110] br[110] wl[41] gnd reram_bitcell_7
Xbit_r42_c110 bl[110] br[110] wl[42] gnd reram_bitcell_7
Xbit_r43_c110 bl[110] br[110] wl[43] gnd reram_bitcell_7
Xbit_r44_c110 bl[110] br[110] wl[44] gnd reram_bitcell_7
Xbit_r45_c110 bl[110] br[110] wl[45] gnd reram_bitcell_7
Xbit_r46_c110 bl[110] br[110] wl[46] gnd reram_bitcell_7
Xbit_r47_c110 bl[110] br[110] wl[47] gnd reram_bitcell_7
Xbit_r48_c110 bl[110] br[110] wl[48] gnd reram_bitcell_7
Xbit_r49_c110 bl[110] br[110] wl[49] gnd reram_bitcell_7
Xbit_r50_c110 bl[110] br[110] wl[50] gnd reram_bitcell_7
Xbit_r51_c110 bl[110] br[110] wl[51] gnd reram_bitcell_7
Xbit_r52_c110 bl[110] br[110] wl[52] gnd reram_bitcell_7
Xbit_r53_c110 bl[110] br[110] wl[53] gnd reram_bitcell_7
Xbit_r54_c110 bl[110] br[110] wl[54] gnd reram_bitcell_7
Xbit_r55_c110 bl[110] br[110] wl[55] gnd reram_bitcell_7
Xbit_r56_c110 bl[110] br[110] wl[56] gnd reram_bitcell_7
Xbit_r57_c110 bl[110] br[110] wl[57] gnd reram_bitcell_7
Xbit_r58_c110 bl[110] br[110] wl[58] gnd reram_bitcell_7
Xbit_r59_c110 bl[110] br[110] wl[59] gnd reram_bitcell_7
Xbit_r60_c110 bl[110] br[110] wl[60] gnd reram_bitcell_7
Xbit_r61_c110 bl[110] br[110] wl[61] gnd reram_bitcell_7
Xbit_r62_c110 bl[110] br[110] wl[62] gnd reram_bitcell_7
Xbit_r63_c110 bl[110] br[110] wl[63] gnd reram_bitcell_7
Xbit_r0_c111 bl[111] br[111] wl[0] gnd reram_bitcell_7
Xbit_r1_c111 bl[111] br[111] wl[1] gnd reram_bitcell_7
Xbit_r2_c111 bl[111] br[111] wl[2] gnd reram_bitcell_7
Xbit_r3_c111 bl[111] br[111] wl[3] gnd reram_bitcell_7
Xbit_r4_c111 bl[111] br[111] wl[4] gnd reram_bitcell_7
Xbit_r5_c111 bl[111] br[111] wl[5] gnd reram_bitcell_7
Xbit_r6_c111 bl[111] br[111] wl[6] gnd reram_bitcell_7
Xbit_r7_c111 bl[111] br[111] wl[7] gnd reram_bitcell_7
Xbit_r8_c111 bl[111] br[111] wl[8] gnd reram_bitcell_7
Xbit_r9_c111 bl[111] br[111] wl[9] gnd reram_bitcell_7
Xbit_r10_c111 bl[111] br[111] wl[10] gnd reram_bitcell_7
Xbit_r11_c111 bl[111] br[111] wl[11] gnd reram_bitcell_7
Xbit_r12_c111 bl[111] br[111] wl[12] gnd reram_bitcell_7
Xbit_r13_c111 bl[111] br[111] wl[13] gnd reram_bitcell_7
Xbit_r14_c111 bl[111] br[111] wl[14] gnd reram_bitcell_7
Xbit_r15_c111 bl[111] br[111] wl[15] gnd reram_bitcell_7
Xbit_r16_c111 bl[111] br[111] wl[16] gnd reram_bitcell_7
Xbit_r17_c111 bl[111] br[111] wl[17] gnd reram_bitcell_7
Xbit_r18_c111 bl[111] br[111] wl[18] gnd reram_bitcell_7
Xbit_r19_c111 bl[111] br[111] wl[19] gnd reram_bitcell_7
Xbit_r20_c111 bl[111] br[111] wl[20] gnd reram_bitcell_7
Xbit_r21_c111 bl[111] br[111] wl[21] gnd reram_bitcell_7
Xbit_r22_c111 bl[111] br[111] wl[22] gnd reram_bitcell_7
Xbit_r23_c111 bl[111] br[111] wl[23] gnd reram_bitcell_7
Xbit_r24_c111 bl[111] br[111] wl[24] gnd reram_bitcell_7
Xbit_r25_c111 bl[111] br[111] wl[25] gnd reram_bitcell_7
Xbit_r26_c111 bl[111] br[111] wl[26] gnd reram_bitcell_7
Xbit_r27_c111 bl[111] br[111] wl[27] gnd reram_bitcell_7
Xbit_r28_c111 bl[111] br[111] wl[28] gnd reram_bitcell_7
Xbit_r29_c111 bl[111] br[111] wl[29] gnd reram_bitcell_7
Xbit_r30_c111 bl[111] br[111] wl[30] gnd reram_bitcell_7
Xbit_r31_c111 bl[111] br[111] wl[31] gnd reram_bitcell_7
Xbit_r32_c111 bl[111] br[111] wl[32] gnd reram_bitcell_7
Xbit_r33_c111 bl[111] br[111] wl[33] gnd reram_bitcell_7
Xbit_r34_c111 bl[111] br[111] wl[34] gnd reram_bitcell_7
Xbit_r35_c111 bl[111] br[111] wl[35] gnd reram_bitcell_7
Xbit_r36_c111 bl[111] br[111] wl[36] gnd reram_bitcell_7
Xbit_r37_c111 bl[111] br[111] wl[37] gnd reram_bitcell_7
Xbit_r38_c111 bl[111] br[111] wl[38] gnd reram_bitcell_7
Xbit_r39_c111 bl[111] br[111] wl[39] gnd reram_bitcell_7
Xbit_r40_c111 bl[111] br[111] wl[40] gnd reram_bitcell_7
Xbit_r41_c111 bl[111] br[111] wl[41] gnd reram_bitcell_7
Xbit_r42_c111 bl[111] br[111] wl[42] gnd reram_bitcell_7
Xbit_r43_c111 bl[111] br[111] wl[43] gnd reram_bitcell_7
Xbit_r44_c111 bl[111] br[111] wl[44] gnd reram_bitcell_7
Xbit_r45_c111 bl[111] br[111] wl[45] gnd reram_bitcell_7
Xbit_r46_c111 bl[111] br[111] wl[46] gnd reram_bitcell_7
Xbit_r47_c111 bl[111] br[111] wl[47] gnd reram_bitcell_7
Xbit_r48_c111 bl[111] br[111] wl[48] gnd reram_bitcell_7
Xbit_r49_c111 bl[111] br[111] wl[49] gnd reram_bitcell_7
Xbit_r50_c111 bl[111] br[111] wl[50] gnd reram_bitcell_7
Xbit_r51_c111 bl[111] br[111] wl[51] gnd reram_bitcell_7
Xbit_r52_c111 bl[111] br[111] wl[52] gnd reram_bitcell_7
Xbit_r53_c111 bl[111] br[111] wl[53] gnd reram_bitcell_7
Xbit_r54_c111 bl[111] br[111] wl[54] gnd reram_bitcell_7
Xbit_r55_c111 bl[111] br[111] wl[55] gnd reram_bitcell_7
Xbit_r56_c111 bl[111] br[111] wl[56] gnd reram_bitcell_7
Xbit_r57_c111 bl[111] br[111] wl[57] gnd reram_bitcell_7
Xbit_r58_c111 bl[111] br[111] wl[58] gnd reram_bitcell_7
Xbit_r59_c111 bl[111] br[111] wl[59] gnd reram_bitcell_7
Xbit_r60_c111 bl[111] br[111] wl[60] gnd reram_bitcell_7
Xbit_r61_c111 bl[111] br[111] wl[61] gnd reram_bitcell_7
Xbit_r62_c111 bl[111] br[111] wl[62] gnd reram_bitcell_7
Xbit_r63_c111 bl[111] br[111] wl[63] gnd reram_bitcell_7
Xbit_r0_c112 bl[112] br[112] wl[0] gnd reram_bitcell_7
Xbit_r1_c112 bl[112] br[112] wl[1] gnd reram_bitcell_7
Xbit_r2_c112 bl[112] br[112] wl[2] gnd reram_bitcell_7
Xbit_r3_c112 bl[112] br[112] wl[3] gnd reram_bitcell_7
Xbit_r4_c112 bl[112] br[112] wl[4] gnd reram_bitcell_7
Xbit_r5_c112 bl[112] br[112] wl[5] gnd reram_bitcell_7
Xbit_r6_c112 bl[112] br[112] wl[6] gnd reram_bitcell_7
Xbit_r7_c112 bl[112] br[112] wl[7] gnd reram_bitcell_7
Xbit_r8_c112 bl[112] br[112] wl[8] gnd reram_bitcell_7
Xbit_r9_c112 bl[112] br[112] wl[9] gnd reram_bitcell_7
Xbit_r10_c112 bl[112] br[112] wl[10] gnd reram_bitcell_7
Xbit_r11_c112 bl[112] br[112] wl[11] gnd reram_bitcell_7
Xbit_r12_c112 bl[112] br[112] wl[12] gnd reram_bitcell_7
Xbit_r13_c112 bl[112] br[112] wl[13] gnd reram_bitcell_7
Xbit_r14_c112 bl[112] br[112] wl[14] gnd reram_bitcell_7
Xbit_r15_c112 bl[112] br[112] wl[15] gnd reram_bitcell_7
Xbit_r16_c112 bl[112] br[112] wl[16] gnd reram_bitcell_7
Xbit_r17_c112 bl[112] br[112] wl[17] gnd reram_bitcell_7
Xbit_r18_c112 bl[112] br[112] wl[18] gnd reram_bitcell_7
Xbit_r19_c112 bl[112] br[112] wl[19] gnd reram_bitcell_7
Xbit_r20_c112 bl[112] br[112] wl[20] gnd reram_bitcell_7
Xbit_r21_c112 bl[112] br[112] wl[21] gnd reram_bitcell_7
Xbit_r22_c112 bl[112] br[112] wl[22] gnd reram_bitcell_7
Xbit_r23_c112 bl[112] br[112] wl[23] gnd reram_bitcell_7
Xbit_r24_c112 bl[112] br[112] wl[24] gnd reram_bitcell_7
Xbit_r25_c112 bl[112] br[112] wl[25] gnd reram_bitcell_7
Xbit_r26_c112 bl[112] br[112] wl[26] gnd reram_bitcell_7
Xbit_r27_c112 bl[112] br[112] wl[27] gnd reram_bitcell_7
Xbit_r28_c112 bl[112] br[112] wl[28] gnd reram_bitcell_7
Xbit_r29_c112 bl[112] br[112] wl[29] gnd reram_bitcell_7
Xbit_r30_c112 bl[112] br[112] wl[30] gnd reram_bitcell_7
Xbit_r31_c112 bl[112] br[112] wl[31] gnd reram_bitcell_7
Xbit_r32_c112 bl[112] br[112] wl[32] gnd reram_bitcell_7
Xbit_r33_c112 bl[112] br[112] wl[33] gnd reram_bitcell_7
Xbit_r34_c112 bl[112] br[112] wl[34] gnd reram_bitcell_7
Xbit_r35_c112 bl[112] br[112] wl[35] gnd reram_bitcell_7
Xbit_r36_c112 bl[112] br[112] wl[36] gnd reram_bitcell_7
Xbit_r37_c112 bl[112] br[112] wl[37] gnd reram_bitcell_7
Xbit_r38_c112 bl[112] br[112] wl[38] gnd reram_bitcell_7
Xbit_r39_c112 bl[112] br[112] wl[39] gnd reram_bitcell_7
Xbit_r40_c112 bl[112] br[112] wl[40] gnd reram_bitcell_7
Xbit_r41_c112 bl[112] br[112] wl[41] gnd reram_bitcell_7
Xbit_r42_c112 bl[112] br[112] wl[42] gnd reram_bitcell_7
Xbit_r43_c112 bl[112] br[112] wl[43] gnd reram_bitcell_7
Xbit_r44_c112 bl[112] br[112] wl[44] gnd reram_bitcell_7
Xbit_r45_c112 bl[112] br[112] wl[45] gnd reram_bitcell_7
Xbit_r46_c112 bl[112] br[112] wl[46] gnd reram_bitcell_7
Xbit_r47_c112 bl[112] br[112] wl[47] gnd reram_bitcell_7
Xbit_r48_c112 bl[112] br[112] wl[48] gnd reram_bitcell_7
Xbit_r49_c112 bl[112] br[112] wl[49] gnd reram_bitcell_7
Xbit_r50_c112 bl[112] br[112] wl[50] gnd reram_bitcell_7
Xbit_r51_c112 bl[112] br[112] wl[51] gnd reram_bitcell_7
Xbit_r52_c112 bl[112] br[112] wl[52] gnd reram_bitcell_7
Xbit_r53_c112 bl[112] br[112] wl[53] gnd reram_bitcell_7
Xbit_r54_c112 bl[112] br[112] wl[54] gnd reram_bitcell_7
Xbit_r55_c112 bl[112] br[112] wl[55] gnd reram_bitcell_7
Xbit_r56_c112 bl[112] br[112] wl[56] gnd reram_bitcell_7
Xbit_r57_c112 bl[112] br[112] wl[57] gnd reram_bitcell_7
Xbit_r58_c112 bl[112] br[112] wl[58] gnd reram_bitcell_7
Xbit_r59_c112 bl[112] br[112] wl[59] gnd reram_bitcell_7
Xbit_r60_c112 bl[112] br[112] wl[60] gnd reram_bitcell_7
Xbit_r61_c112 bl[112] br[112] wl[61] gnd reram_bitcell_7
Xbit_r62_c112 bl[112] br[112] wl[62] gnd reram_bitcell_7
Xbit_r63_c112 bl[112] br[112] wl[63] gnd reram_bitcell_7
Xbit_r0_c113 bl[113] br[113] wl[0] gnd reram_bitcell_7
Xbit_r1_c113 bl[113] br[113] wl[1] gnd reram_bitcell_7
Xbit_r2_c113 bl[113] br[113] wl[2] gnd reram_bitcell_7
Xbit_r3_c113 bl[113] br[113] wl[3] gnd reram_bitcell_7
Xbit_r4_c113 bl[113] br[113] wl[4] gnd reram_bitcell_7
Xbit_r5_c113 bl[113] br[113] wl[5] gnd reram_bitcell_7
Xbit_r6_c113 bl[113] br[113] wl[6] gnd reram_bitcell_7
Xbit_r7_c113 bl[113] br[113] wl[7] gnd reram_bitcell_7
Xbit_r8_c113 bl[113] br[113] wl[8] gnd reram_bitcell_7
Xbit_r9_c113 bl[113] br[113] wl[9] gnd reram_bitcell_7
Xbit_r10_c113 bl[113] br[113] wl[10] gnd reram_bitcell_7
Xbit_r11_c113 bl[113] br[113] wl[11] gnd reram_bitcell_7
Xbit_r12_c113 bl[113] br[113] wl[12] gnd reram_bitcell_7
Xbit_r13_c113 bl[113] br[113] wl[13] gnd reram_bitcell_7
Xbit_r14_c113 bl[113] br[113] wl[14] gnd reram_bitcell_7
Xbit_r15_c113 bl[113] br[113] wl[15] gnd reram_bitcell_7
Xbit_r16_c113 bl[113] br[113] wl[16] gnd reram_bitcell_7
Xbit_r17_c113 bl[113] br[113] wl[17] gnd reram_bitcell_7
Xbit_r18_c113 bl[113] br[113] wl[18] gnd reram_bitcell_7
Xbit_r19_c113 bl[113] br[113] wl[19] gnd reram_bitcell_7
Xbit_r20_c113 bl[113] br[113] wl[20] gnd reram_bitcell_7
Xbit_r21_c113 bl[113] br[113] wl[21] gnd reram_bitcell_7
Xbit_r22_c113 bl[113] br[113] wl[22] gnd reram_bitcell_7
Xbit_r23_c113 bl[113] br[113] wl[23] gnd reram_bitcell_7
Xbit_r24_c113 bl[113] br[113] wl[24] gnd reram_bitcell_7
Xbit_r25_c113 bl[113] br[113] wl[25] gnd reram_bitcell_7
Xbit_r26_c113 bl[113] br[113] wl[26] gnd reram_bitcell_7
Xbit_r27_c113 bl[113] br[113] wl[27] gnd reram_bitcell_7
Xbit_r28_c113 bl[113] br[113] wl[28] gnd reram_bitcell_7
Xbit_r29_c113 bl[113] br[113] wl[29] gnd reram_bitcell_7
Xbit_r30_c113 bl[113] br[113] wl[30] gnd reram_bitcell_7
Xbit_r31_c113 bl[113] br[113] wl[31] gnd reram_bitcell_7
Xbit_r32_c113 bl[113] br[113] wl[32] gnd reram_bitcell_7
Xbit_r33_c113 bl[113] br[113] wl[33] gnd reram_bitcell_7
Xbit_r34_c113 bl[113] br[113] wl[34] gnd reram_bitcell_7
Xbit_r35_c113 bl[113] br[113] wl[35] gnd reram_bitcell_7
Xbit_r36_c113 bl[113] br[113] wl[36] gnd reram_bitcell_7
Xbit_r37_c113 bl[113] br[113] wl[37] gnd reram_bitcell_7
Xbit_r38_c113 bl[113] br[113] wl[38] gnd reram_bitcell_7
Xbit_r39_c113 bl[113] br[113] wl[39] gnd reram_bitcell_7
Xbit_r40_c113 bl[113] br[113] wl[40] gnd reram_bitcell_7
Xbit_r41_c113 bl[113] br[113] wl[41] gnd reram_bitcell_7
Xbit_r42_c113 bl[113] br[113] wl[42] gnd reram_bitcell_7
Xbit_r43_c113 bl[113] br[113] wl[43] gnd reram_bitcell_7
Xbit_r44_c113 bl[113] br[113] wl[44] gnd reram_bitcell_7
Xbit_r45_c113 bl[113] br[113] wl[45] gnd reram_bitcell_7
Xbit_r46_c113 bl[113] br[113] wl[46] gnd reram_bitcell_7
Xbit_r47_c113 bl[113] br[113] wl[47] gnd reram_bitcell_7
Xbit_r48_c113 bl[113] br[113] wl[48] gnd reram_bitcell_7
Xbit_r49_c113 bl[113] br[113] wl[49] gnd reram_bitcell_7
Xbit_r50_c113 bl[113] br[113] wl[50] gnd reram_bitcell_7
Xbit_r51_c113 bl[113] br[113] wl[51] gnd reram_bitcell_7
Xbit_r52_c113 bl[113] br[113] wl[52] gnd reram_bitcell_7
Xbit_r53_c113 bl[113] br[113] wl[53] gnd reram_bitcell_7
Xbit_r54_c113 bl[113] br[113] wl[54] gnd reram_bitcell_7
Xbit_r55_c113 bl[113] br[113] wl[55] gnd reram_bitcell_7
Xbit_r56_c113 bl[113] br[113] wl[56] gnd reram_bitcell_7
Xbit_r57_c113 bl[113] br[113] wl[57] gnd reram_bitcell_7
Xbit_r58_c113 bl[113] br[113] wl[58] gnd reram_bitcell_7
Xbit_r59_c113 bl[113] br[113] wl[59] gnd reram_bitcell_7
Xbit_r60_c113 bl[113] br[113] wl[60] gnd reram_bitcell_7
Xbit_r61_c113 bl[113] br[113] wl[61] gnd reram_bitcell_7
Xbit_r62_c113 bl[113] br[113] wl[62] gnd reram_bitcell_7
Xbit_r63_c113 bl[113] br[113] wl[63] gnd reram_bitcell_7
Xbit_r0_c114 bl[114] br[114] wl[0] gnd reram_bitcell_7
Xbit_r1_c114 bl[114] br[114] wl[1] gnd reram_bitcell_7
Xbit_r2_c114 bl[114] br[114] wl[2] gnd reram_bitcell_7
Xbit_r3_c114 bl[114] br[114] wl[3] gnd reram_bitcell_7
Xbit_r4_c114 bl[114] br[114] wl[4] gnd reram_bitcell_7
Xbit_r5_c114 bl[114] br[114] wl[5] gnd reram_bitcell_7
Xbit_r6_c114 bl[114] br[114] wl[6] gnd reram_bitcell_7
Xbit_r7_c114 bl[114] br[114] wl[7] gnd reram_bitcell_7
Xbit_r8_c114 bl[114] br[114] wl[8] gnd reram_bitcell_7
Xbit_r9_c114 bl[114] br[114] wl[9] gnd reram_bitcell_7
Xbit_r10_c114 bl[114] br[114] wl[10] gnd reram_bitcell_7
Xbit_r11_c114 bl[114] br[114] wl[11] gnd reram_bitcell_7
Xbit_r12_c114 bl[114] br[114] wl[12] gnd reram_bitcell_7
Xbit_r13_c114 bl[114] br[114] wl[13] gnd reram_bitcell_7
Xbit_r14_c114 bl[114] br[114] wl[14] gnd reram_bitcell_7
Xbit_r15_c114 bl[114] br[114] wl[15] gnd reram_bitcell_7
Xbit_r16_c114 bl[114] br[114] wl[16] gnd reram_bitcell_7
Xbit_r17_c114 bl[114] br[114] wl[17] gnd reram_bitcell_7
Xbit_r18_c114 bl[114] br[114] wl[18] gnd reram_bitcell_7
Xbit_r19_c114 bl[114] br[114] wl[19] gnd reram_bitcell_7
Xbit_r20_c114 bl[114] br[114] wl[20] gnd reram_bitcell_7
Xbit_r21_c114 bl[114] br[114] wl[21] gnd reram_bitcell_7
Xbit_r22_c114 bl[114] br[114] wl[22] gnd reram_bitcell_7
Xbit_r23_c114 bl[114] br[114] wl[23] gnd reram_bitcell_7
Xbit_r24_c114 bl[114] br[114] wl[24] gnd reram_bitcell_7
Xbit_r25_c114 bl[114] br[114] wl[25] gnd reram_bitcell_7
Xbit_r26_c114 bl[114] br[114] wl[26] gnd reram_bitcell_7
Xbit_r27_c114 bl[114] br[114] wl[27] gnd reram_bitcell_7
Xbit_r28_c114 bl[114] br[114] wl[28] gnd reram_bitcell_7
Xbit_r29_c114 bl[114] br[114] wl[29] gnd reram_bitcell_7
Xbit_r30_c114 bl[114] br[114] wl[30] gnd reram_bitcell_7
Xbit_r31_c114 bl[114] br[114] wl[31] gnd reram_bitcell_7
Xbit_r32_c114 bl[114] br[114] wl[32] gnd reram_bitcell_7
Xbit_r33_c114 bl[114] br[114] wl[33] gnd reram_bitcell_7
Xbit_r34_c114 bl[114] br[114] wl[34] gnd reram_bitcell_7
Xbit_r35_c114 bl[114] br[114] wl[35] gnd reram_bitcell_7
Xbit_r36_c114 bl[114] br[114] wl[36] gnd reram_bitcell_7
Xbit_r37_c114 bl[114] br[114] wl[37] gnd reram_bitcell_7
Xbit_r38_c114 bl[114] br[114] wl[38] gnd reram_bitcell_7
Xbit_r39_c114 bl[114] br[114] wl[39] gnd reram_bitcell_7
Xbit_r40_c114 bl[114] br[114] wl[40] gnd reram_bitcell_7
Xbit_r41_c114 bl[114] br[114] wl[41] gnd reram_bitcell_7
Xbit_r42_c114 bl[114] br[114] wl[42] gnd reram_bitcell_7
Xbit_r43_c114 bl[114] br[114] wl[43] gnd reram_bitcell_7
Xbit_r44_c114 bl[114] br[114] wl[44] gnd reram_bitcell_7
Xbit_r45_c114 bl[114] br[114] wl[45] gnd reram_bitcell_7
Xbit_r46_c114 bl[114] br[114] wl[46] gnd reram_bitcell_7
Xbit_r47_c114 bl[114] br[114] wl[47] gnd reram_bitcell_7
Xbit_r48_c114 bl[114] br[114] wl[48] gnd reram_bitcell_7
Xbit_r49_c114 bl[114] br[114] wl[49] gnd reram_bitcell_7
Xbit_r50_c114 bl[114] br[114] wl[50] gnd reram_bitcell_7
Xbit_r51_c114 bl[114] br[114] wl[51] gnd reram_bitcell_7
Xbit_r52_c114 bl[114] br[114] wl[52] gnd reram_bitcell_7
Xbit_r53_c114 bl[114] br[114] wl[53] gnd reram_bitcell_7
Xbit_r54_c114 bl[114] br[114] wl[54] gnd reram_bitcell_7
Xbit_r55_c114 bl[114] br[114] wl[55] gnd reram_bitcell_7
Xbit_r56_c114 bl[114] br[114] wl[56] gnd reram_bitcell_7
Xbit_r57_c114 bl[114] br[114] wl[57] gnd reram_bitcell_7
Xbit_r58_c114 bl[114] br[114] wl[58] gnd reram_bitcell_7
Xbit_r59_c114 bl[114] br[114] wl[59] gnd reram_bitcell_7
Xbit_r60_c114 bl[114] br[114] wl[60] gnd reram_bitcell_7
Xbit_r61_c114 bl[114] br[114] wl[61] gnd reram_bitcell_7
Xbit_r62_c114 bl[114] br[114] wl[62] gnd reram_bitcell_7
Xbit_r63_c114 bl[114] br[114] wl[63] gnd reram_bitcell_7
Xbit_r0_c115 bl[115] br[115] wl[0] gnd reram_bitcell_7
Xbit_r1_c115 bl[115] br[115] wl[1] gnd reram_bitcell_7
Xbit_r2_c115 bl[115] br[115] wl[2] gnd reram_bitcell_7
Xbit_r3_c115 bl[115] br[115] wl[3] gnd reram_bitcell_7
Xbit_r4_c115 bl[115] br[115] wl[4] gnd reram_bitcell_7
Xbit_r5_c115 bl[115] br[115] wl[5] gnd reram_bitcell_7
Xbit_r6_c115 bl[115] br[115] wl[6] gnd reram_bitcell_7
Xbit_r7_c115 bl[115] br[115] wl[7] gnd reram_bitcell_7
Xbit_r8_c115 bl[115] br[115] wl[8] gnd reram_bitcell_7
Xbit_r9_c115 bl[115] br[115] wl[9] gnd reram_bitcell_7
Xbit_r10_c115 bl[115] br[115] wl[10] gnd reram_bitcell_7
Xbit_r11_c115 bl[115] br[115] wl[11] gnd reram_bitcell_7
Xbit_r12_c115 bl[115] br[115] wl[12] gnd reram_bitcell_7
Xbit_r13_c115 bl[115] br[115] wl[13] gnd reram_bitcell_7
Xbit_r14_c115 bl[115] br[115] wl[14] gnd reram_bitcell_7
Xbit_r15_c115 bl[115] br[115] wl[15] gnd reram_bitcell_7
Xbit_r16_c115 bl[115] br[115] wl[16] gnd reram_bitcell_7
Xbit_r17_c115 bl[115] br[115] wl[17] gnd reram_bitcell_7
Xbit_r18_c115 bl[115] br[115] wl[18] gnd reram_bitcell_7
Xbit_r19_c115 bl[115] br[115] wl[19] gnd reram_bitcell_7
Xbit_r20_c115 bl[115] br[115] wl[20] gnd reram_bitcell_7
Xbit_r21_c115 bl[115] br[115] wl[21] gnd reram_bitcell_7
Xbit_r22_c115 bl[115] br[115] wl[22] gnd reram_bitcell_7
Xbit_r23_c115 bl[115] br[115] wl[23] gnd reram_bitcell_7
Xbit_r24_c115 bl[115] br[115] wl[24] gnd reram_bitcell_7
Xbit_r25_c115 bl[115] br[115] wl[25] gnd reram_bitcell_7
Xbit_r26_c115 bl[115] br[115] wl[26] gnd reram_bitcell_7
Xbit_r27_c115 bl[115] br[115] wl[27] gnd reram_bitcell_7
Xbit_r28_c115 bl[115] br[115] wl[28] gnd reram_bitcell_7
Xbit_r29_c115 bl[115] br[115] wl[29] gnd reram_bitcell_7
Xbit_r30_c115 bl[115] br[115] wl[30] gnd reram_bitcell_7
Xbit_r31_c115 bl[115] br[115] wl[31] gnd reram_bitcell_7
Xbit_r32_c115 bl[115] br[115] wl[32] gnd reram_bitcell_7
Xbit_r33_c115 bl[115] br[115] wl[33] gnd reram_bitcell_7
Xbit_r34_c115 bl[115] br[115] wl[34] gnd reram_bitcell_7
Xbit_r35_c115 bl[115] br[115] wl[35] gnd reram_bitcell_7
Xbit_r36_c115 bl[115] br[115] wl[36] gnd reram_bitcell_7
Xbit_r37_c115 bl[115] br[115] wl[37] gnd reram_bitcell_7
Xbit_r38_c115 bl[115] br[115] wl[38] gnd reram_bitcell_7
Xbit_r39_c115 bl[115] br[115] wl[39] gnd reram_bitcell_7
Xbit_r40_c115 bl[115] br[115] wl[40] gnd reram_bitcell_7
Xbit_r41_c115 bl[115] br[115] wl[41] gnd reram_bitcell_7
Xbit_r42_c115 bl[115] br[115] wl[42] gnd reram_bitcell_7
Xbit_r43_c115 bl[115] br[115] wl[43] gnd reram_bitcell_7
Xbit_r44_c115 bl[115] br[115] wl[44] gnd reram_bitcell_7
Xbit_r45_c115 bl[115] br[115] wl[45] gnd reram_bitcell_7
Xbit_r46_c115 bl[115] br[115] wl[46] gnd reram_bitcell_7
Xbit_r47_c115 bl[115] br[115] wl[47] gnd reram_bitcell_7
Xbit_r48_c115 bl[115] br[115] wl[48] gnd reram_bitcell_7
Xbit_r49_c115 bl[115] br[115] wl[49] gnd reram_bitcell_7
Xbit_r50_c115 bl[115] br[115] wl[50] gnd reram_bitcell_7
Xbit_r51_c115 bl[115] br[115] wl[51] gnd reram_bitcell_7
Xbit_r52_c115 bl[115] br[115] wl[52] gnd reram_bitcell_7
Xbit_r53_c115 bl[115] br[115] wl[53] gnd reram_bitcell_7
Xbit_r54_c115 bl[115] br[115] wl[54] gnd reram_bitcell_7
Xbit_r55_c115 bl[115] br[115] wl[55] gnd reram_bitcell_7
Xbit_r56_c115 bl[115] br[115] wl[56] gnd reram_bitcell_7
Xbit_r57_c115 bl[115] br[115] wl[57] gnd reram_bitcell_7
Xbit_r58_c115 bl[115] br[115] wl[58] gnd reram_bitcell_7
Xbit_r59_c115 bl[115] br[115] wl[59] gnd reram_bitcell_7
Xbit_r60_c115 bl[115] br[115] wl[60] gnd reram_bitcell_7
Xbit_r61_c115 bl[115] br[115] wl[61] gnd reram_bitcell_7
Xbit_r62_c115 bl[115] br[115] wl[62] gnd reram_bitcell_7
Xbit_r63_c115 bl[115] br[115] wl[63] gnd reram_bitcell_7
Xbit_r0_c116 bl[116] br[116] wl[0] gnd reram_bitcell_7
Xbit_r1_c116 bl[116] br[116] wl[1] gnd reram_bitcell_7
Xbit_r2_c116 bl[116] br[116] wl[2] gnd reram_bitcell_7
Xbit_r3_c116 bl[116] br[116] wl[3] gnd reram_bitcell_7
Xbit_r4_c116 bl[116] br[116] wl[4] gnd reram_bitcell_7
Xbit_r5_c116 bl[116] br[116] wl[5] gnd reram_bitcell_7
Xbit_r6_c116 bl[116] br[116] wl[6] gnd reram_bitcell_7
Xbit_r7_c116 bl[116] br[116] wl[7] gnd reram_bitcell_7
Xbit_r8_c116 bl[116] br[116] wl[8] gnd reram_bitcell_7
Xbit_r9_c116 bl[116] br[116] wl[9] gnd reram_bitcell_7
Xbit_r10_c116 bl[116] br[116] wl[10] gnd reram_bitcell_7
Xbit_r11_c116 bl[116] br[116] wl[11] gnd reram_bitcell_7
Xbit_r12_c116 bl[116] br[116] wl[12] gnd reram_bitcell_7
Xbit_r13_c116 bl[116] br[116] wl[13] gnd reram_bitcell_7
Xbit_r14_c116 bl[116] br[116] wl[14] gnd reram_bitcell_7
Xbit_r15_c116 bl[116] br[116] wl[15] gnd reram_bitcell_7
Xbit_r16_c116 bl[116] br[116] wl[16] gnd reram_bitcell_7
Xbit_r17_c116 bl[116] br[116] wl[17] gnd reram_bitcell_7
Xbit_r18_c116 bl[116] br[116] wl[18] gnd reram_bitcell_7
Xbit_r19_c116 bl[116] br[116] wl[19] gnd reram_bitcell_7
Xbit_r20_c116 bl[116] br[116] wl[20] gnd reram_bitcell_7
Xbit_r21_c116 bl[116] br[116] wl[21] gnd reram_bitcell_7
Xbit_r22_c116 bl[116] br[116] wl[22] gnd reram_bitcell_7
Xbit_r23_c116 bl[116] br[116] wl[23] gnd reram_bitcell_7
Xbit_r24_c116 bl[116] br[116] wl[24] gnd reram_bitcell_7
Xbit_r25_c116 bl[116] br[116] wl[25] gnd reram_bitcell_7
Xbit_r26_c116 bl[116] br[116] wl[26] gnd reram_bitcell_7
Xbit_r27_c116 bl[116] br[116] wl[27] gnd reram_bitcell_7
Xbit_r28_c116 bl[116] br[116] wl[28] gnd reram_bitcell_7
Xbit_r29_c116 bl[116] br[116] wl[29] gnd reram_bitcell_7
Xbit_r30_c116 bl[116] br[116] wl[30] gnd reram_bitcell_7
Xbit_r31_c116 bl[116] br[116] wl[31] gnd reram_bitcell_7
Xbit_r32_c116 bl[116] br[116] wl[32] gnd reram_bitcell_7
Xbit_r33_c116 bl[116] br[116] wl[33] gnd reram_bitcell_7
Xbit_r34_c116 bl[116] br[116] wl[34] gnd reram_bitcell_7
Xbit_r35_c116 bl[116] br[116] wl[35] gnd reram_bitcell_7
Xbit_r36_c116 bl[116] br[116] wl[36] gnd reram_bitcell_7
Xbit_r37_c116 bl[116] br[116] wl[37] gnd reram_bitcell_7
Xbit_r38_c116 bl[116] br[116] wl[38] gnd reram_bitcell_7
Xbit_r39_c116 bl[116] br[116] wl[39] gnd reram_bitcell_7
Xbit_r40_c116 bl[116] br[116] wl[40] gnd reram_bitcell_7
Xbit_r41_c116 bl[116] br[116] wl[41] gnd reram_bitcell_7
Xbit_r42_c116 bl[116] br[116] wl[42] gnd reram_bitcell_7
Xbit_r43_c116 bl[116] br[116] wl[43] gnd reram_bitcell_7
Xbit_r44_c116 bl[116] br[116] wl[44] gnd reram_bitcell_7
Xbit_r45_c116 bl[116] br[116] wl[45] gnd reram_bitcell_7
Xbit_r46_c116 bl[116] br[116] wl[46] gnd reram_bitcell_7
Xbit_r47_c116 bl[116] br[116] wl[47] gnd reram_bitcell_7
Xbit_r48_c116 bl[116] br[116] wl[48] gnd reram_bitcell_7
Xbit_r49_c116 bl[116] br[116] wl[49] gnd reram_bitcell_7
Xbit_r50_c116 bl[116] br[116] wl[50] gnd reram_bitcell_7
Xbit_r51_c116 bl[116] br[116] wl[51] gnd reram_bitcell_7
Xbit_r52_c116 bl[116] br[116] wl[52] gnd reram_bitcell_7
Xbit_r53_c116 bl[116] br[116] wl[53] gnd reram_bitcell_7
Xbit_r54_c116 bl[116] br[116] wl[54] gnd reram_bitcell_7
Xbit_r55_c116 bl[116] br[116] wl[55] gnd reram_bitcell_7
Xbit_r56_c116 bl[116] br[116] wl[56] gnd reram_bitcell_7
Xbit_r57_c116 bl[116] br[116] wl[57] gnd reram_bitcell_7
Xbit_r58_c116 bl[116] br[116] wl[58] gnd reram_bitcell_7
Xbit_r59_c116 bl[116] br[116] wl[59] gnd reram_bitcell_7
Xbit_r60_c116 bl[116] br[116] wl[60] gnd reram_bitcell_7
Xbit_r61_c116 bl[116] br[116] wl[61] gnd reram_bitcell_7
Xbit_r62_c116 bl[116] br[116] wl[62] gnd reram_bitcell_7
Xbit_r63_c116 bl[116] br[116] wl[63] gnd reram_bitcell_7
Xbit_r0_c117 bl[117] br[117] wl[0] gnd reram_bitcell_7
Xbit_r1_c117 bl[117] br[117] wl[1] gnd reram_bitcell_7
Xbit_r2_c117 bl[117] br[117] wl[2] gnd reram_bitcell_7
Xbit_r3_c117 bl[117] br[117] wl[3] gnd reram_bitcell_7
Xbit_r4_c117 bl[117] br[117] wl[4] gnd reram_bitcell_7
Xbit_r5_c117 bl[117] br[117] wl[5] gnd reram_bitcell_7
Xbit_r6_c117 bl[117] br[117] wl[6] gnd reram_bitcell_7
Xbit_r7_c117 bl[117] br[117] wl[7] gnd reram_bitcell_7
Xbit_r8_c117 bl[117] br[117] wl[8] gnd reram_bitcell_7
Xbit_r9_c117 bl[117] br[117] wl[9] gnd reram_bitcell_7
Xbit_r10_c117 bl[117] br[117] wl[10] gnd reram_bitcell_7
Xbit_r11_c117 bl[117] br[117] wl[11] gnd reram_bitcell_7
Xbit_r12_c117 bl[117] br[117] wl[12] gnd reram_bitcell_7
Xbit_r13_c117 bl[117] br[117] wl[13] gnd reram_bitcell_7
Xbit_r14_c117 bl[117] br[117] wl[14] gnd reram_bitcell_7
Xbit_r15_c117 bl[117] br[117] wl[15] gnd reram_bitcell_7
Xbit_r16_c117 bl[117] br[117] wl[16] gnd reram_bitcell_7
Xbit_r17_c117 bl[117] br[117] wl[17] gnd reram_bitcell_7
Xbit_r18_c117 bl[117] br[117] wl[18] gnd reram_bitcell_7
Xbit_r19_c117 bl[117] br[117] wl[19] gnd reram_bitcell_7
Xbit_r20_c117 bl[117] br[117] wl[20] gnd reram_bitcell_7
Xbit_r21_c117 bl[117] br[117] wl[21] gnd reram_bitcell_7
Xbit_r22_c117 bl[117] br[117] wl[22] gnd reram_bitcell_7
Xbit_r23_c117 bl[117] br[117] wl[23] gnd reram_bitcell_7
Xbit_r24_c117 bl[117] br[117] wl[24] gnd reram_bitcell_7
Xbit_r25_c117 bl[117] br[117] wl[25] gnd reram_bitcell_7
Xbit_r26_c117 bl[117] br[117] wl[26] gnd reram_bitcell_7
Xbit_r27_c117 bl[117] br[117] wl[27] gnd reram_bitcell_7
Xbit_r28_c117 bl[117] br[117] wl[28] gnd reram_bitcell_7
Xbit_r29_c117 bl[117] br[117] wl[29] gnd reram_bitcell_7
Xbit_r30_c117 bl[117] br[117] wl[30] gnd reram_bitcell_7
Xbit_r31_c117 bl[117] br[117] wl[31] gnd reram_bitcell_7
Xbit_r32_c117 bl[117] br[117] wl[32] gnd reram_bitcell_7
Xbit_r33_c117 bl[117] br[117] wl[33] gnd reram_bitcell_7
Xbit_r34_c117 bl[117] br[117] wl[34] gnd reram_bitcell_7
Xbit_r35_c117 bl[117] br[117] wl[35] gnd reram_bitcell_7
Xbit_r36_c117 bl[117] br[117] wl[36] gnd reram_bitcell_7
Xbit_r37_c117 bl[117] br[117] wl[37] gnd reram_bitcell_7
Xbit_r38_c117 bl[117] br[117] wl[38] gnd reram_bitcell_7
Xbit_r39_c117 bl[117] br[117] wl[39] gnd reram_bitcell_7
Xbit_r40_c117 bl[117] br[117] wl[40] gnd reram_bitcell_7
Xbit_r41_c117 bl[117] br[117] wl[41] gnd reram_bitcell_7
Xbit_r42_c117 bl[117] br[117] wl[42] gnd reram_bitcell_7
Xbit_r43_c117 bl[117] br[117] wl[43] gnd reram_bitcell_7
Xbit_r44_c117 bl[117] br[117] wl[44] gnd reram_bitcell_7
Xbit_r45_c117 bl[117] br[117] wl[45] gnd reram_bitcell_7
Xbit_r46_c117 bl[117] br[117] wl[46] gnd reram_bitcell_7
Xbit_r47_c117 bl[117] br[117] wl[47] gnd reram_bitcell_7
Xbit_r48_c117 bl[117] br[117] wl[48] gnd reram_bitcell_7
Xbit_r49_c117 bl[117] br[117] wl[49] gnd reram_bitcell_7
Xbit_r50_c117 bl[117] br[117] wl[50] gnd reram_bitcell_7
Xbit_r51_c117 bl[117] br[117] wl[51] gnd reram_bitcell_7
Xbit_r52_c117 bl[117] br[117] wl[52] gnd reram_bitcell_7
Xbit_r53_c117 bl[117] br[117] wl[53] gnd reram_bitcell_7
Xbit_r54_c117 bl[117] br[117] wl[54] gnd reram_bitcell_7
Xbit_r55_c117 bl[117] br[117] wl[55] gnd reram_bitcell_7
Xbit_r56_c117 bl[117] br[117] wl[56] gnd reram_bitcell_7
Xbit_r57_c117 bl[117] br[117] wl[57] gnd reram_bitcell_7
Xbit_r58_c117 bl[117] br[117] wl[58] gnd reram_bitcell_7
Xbit_r59_c117 bl[117] br[117] wl[59] gnd reram_bitcell_7
Xbit_r60_c117 bl[117] br[117] wl[60] gnd reram_bitcell_7
Xbit_r61_c117 bl[117] br[117] wl[61] gnd reram_bitcell_7
Xbit_r62_c117 bl[117] br[117] wl[62] gnd reram_bitcell_7
Xbit_r63_c117 bl[117] br[117] wl[63] gnd reram_bitcell_7
Xbit_r0_c118 bl[118] br[118] wl[0] gnd reram_bitcell_7
Xbit_r1_c118 bl[118] br[118] wl[1] gnd reram_bitcell_7
Xbit_r2_c118 bl[118] br[118] wl[2] gnd reram_bitcell_7
Xbit_r3_c118 bl[118] br[118] wl[3] gnd reram_bitcell_7
Xbit_r4_c118 bl[118] br[118] wl[4] gnd reram_bitcell_7
Xbit_r5_c118 bl[118] br[118] wl[5] gnd reram_bitcell_7
Xbit_r6_c118 bl[118] br[118] wl[6] gnd reram_bitcell_7
Xbit_r7_c118 bl[118] br[118] wl[7] gnd reram_bitcell_7
Xbit_r8_c118 bl[118] br[118] wl[8] gnd reram_bitcell_7
Xbit_r9_c118 bl[118] br[118] wl[9] gnd reram_bitcell_7
Xbit_r10_c118 bl[118] br[118] wl[10] gnd reram_bitcell_7
Xbit_r11_c118 bl[118] br[118] wl[11] gnd reram_bitcell_7
Xbit_r12_c118 bl[118] br[118] wl[12] gnd reram_bitcell_7
Xbit_r13_c118 bl[118] br[118] wl[13] gnd reram_bitcell_7
Xbit_r14_c118 bl[118] br[118] wl[14] gnd reram_bitcell_7
Xbit_r15_c118 bl[118] br[118] wl[15] gnd reram_bitcell_7
Xbit_r16_c118 bl[118] br[118] wl[16] gnd reram_bitcell_7
Xbit_r17_c118 bl[118] br[118] wl[17] gnd reram_bitcell_7
Xbit_r18_c118 bl[118] br[118] wl[18] gnd reram_bitcell_7
Xbit_r19_c118 bl[118] br[118] wl[19] gnd reram_bitcell_7
Xbit_r20_c118 bl[118] br[118] wl[20] gnd reram_bitcell_7
Xbit_r21_c118 bl[118] br[118] wl[21] gnd reram_bitcell_7
Xbit_r22_c118 bl[118] br[118] wl[22] gnd reram_bitcell_7
Xbit_r23_c118 bl[118] br[118] wl[23] gnd reram_bitcell_7
Xbit_r24_c118 bl[118] br[118] wl[24] gnd reram_bitcell_7
Xbit_r25_c118 bl[118] br[118] wl[25] gnd reram_bitcell_7
Xbit_r26_c118 bl[118] br[118] wl[26] gnd reram_bitcell_7
Xbit_r27_c118 bl[118] br[118] wl[27] gnd reram_bitcell_7
Xbit_r28_c118 bl[118] br[118] wl[28] gnd reram_bitcell_7
Xbit_r29_c118 bl[118] br[118] wl[29] gnd reram_bitcell_7
Xbit_r30_c118 bl[118] br[118] wl[30] gnd reram_bitcell_7
Xbit_r31_c118 bl[118] br[118] wl[31] gnd reram_bitcell_7
Xbit_r32_c118 bl[118] br[118] wl[32] gnd reram_bitcell_7
Xbit_r33_c118 bl[118] br[118] wl[33] gnd reram_bitcell_7
Xbit_r34_c118 bl[118] br[118] wl[34] gnd reram_bitcell_7
Xbit_r35_c118 bl[118] br[118] wl[35] gnd reram_bitcell_7
Xbit_r36_c118 bl[118] br[118] wl[36] gnd reram_bitcell_7
Xbit_r37_c118 bl[118] br[118] wl[37] gnd reram_bitcell_7
Xbit_r38_c118 bl[118] br[118] wl[38] gnd reram_bitcell_7
Xbit_r39_c118 bl[118] br[118] wl[39] gnd reram_bitcell_7
Xbit_r40_c118 bl[118] br[118] wl[40] gnd reram_bitcell_7
Xbit_r41_c118 bl[118] br[118] wl[41] gnd reram_bitcell_7
Xbit_r42_c118 bl[118] br[118] wl[42] gnd reram_bitcell_7
Xbit_r43_c118 bl[118] br[118] wl[43] gnd reram_bitcell_7
Xbit_r44_c118 bl[118] br[118] wl[44] gnd reram_bitcell_7
Xbit_r45_c118 bl[118] br[118] wl[45] gnd reram_bitcell_7
Xbit_r46_c118 bl[118] br[118] wl[46] gnd reram_bitcell_7
Xbit_r47_c118 bl[118] br[118] wl[47] gnd reram_bitcell_7
Xbit_r48_c118 bl[118] br[118] wl[48] gnd reram_bitcell_7
Xbit_r49_c118 bl[118] br[118] wl[49] gnd reram_bitcell_7
Xbit_r50_c118 bl[118] br[118] wl[50] gnd reram_bitcell_7
Xbit_r51_c118 bl[118] br[118] wl[51] gnd reram_bitcell_7
Xbit_r52_c118 bl[118] br[118] wl[52] gnd reram_bitcell_7
Xbit_r53_c118 bl[118] br[118] wl[53] gnd reram_bitcell_7
Xbit_r54_c118 bl[118] br[118] wl[54] gnd reram_bitcell_7
Xbit_r55_c118 bl[118] br[118] wl[55] gnd reram_bitcell_7
Xbit_r56_c118 bl[118] br[118] wl[56] gnd reram_bitcell_7
Xbit_r57_c118 bl[118] br[118] wl[57] gnd reram_bitcell_7
Xbit_r58_c118 bl[118] br[118] wl[58] gnd reram_bitcell_7
Xbit_r59_c118 bl[118] br[118] wl[59] gnd reram_bitcell_7
Xbit_r60_c118 bl[118] br[118] wl[60] gnd reram_bitcell_7
Xbit_r61_c118 bl[118] br[118] wl[61] gnd reram_bitcell_7
Xbit_r62_c118 bl[118] br[118] wl[62] gnd reram_bitcell_7
Xbit_r63_c118 bl[118] br[118] wl[63] gnd reram_bitcell_7
Xbit_r0_c119 bl[119] br[119] wl[0] gnd reram_bitcell_7
Xbit_r1_c119 bl[119] br[119] wl[1] gnd reram_bitcell_7
Xbit_r2_c119 bl[119] br[119] wl[2] gnd reram_bitcell_7
Xbit_r3_c119 bl[119] br[119] wl[3] gnd reram_bitcell_7
Xbit_r4_c119 bl[119] br[119] wl[4] gnd reram_bitcell_7
Xbit_r5_c119 bl[119] br[119] wl[5] gnd reram_bitcell_7
Xbit_r6_c119 bl[119] br[119] wl[6] gnd reram_bitcell_7
Xbit_r7_c119 bl[119] br[119] wl[7] gnd reram_bitcell_7
Xbit_r8_c119 bl[119] br[119] wl[8] gnd reram_bitcell_7
Xbit_r9_c119 bl[119] br[119] wl[9] gnd reram_bitcell_7
Xbit_r10_c119 bl[119] br[119] wl[10] gnd reram_bitcell_7
Xbit_r11_c119 bl[119] br[119] wl[11] gnd reram_bitcell_7
Xbit_r12_c119 bl[119] br[119] wl[12] gnd reram_bitcell_7
Xbit_r13_c119 bl[119] br[119] wl[13] gnd reram_bitcell_7
Xbit_r14_c119 bl[119] br[119] wl[14] gnd reram_bitcell_7
Xbit_r15_c119 bl[119] br[119] wl[15] gnd reram_bitcell_7
Xbit_r16_c119 bl[119] br[119] wl[16] gnd reram_bitcell_7
Xbit_r17_c119 bl[119] br[119] wl[17] gnd reram_bitcell_7
Xbit_r18_c119 bl[119] br[119] wl[18] gnd reram_bitcell_7
Xbit_r19_c119 bl[119] br[119] wl[19] gnd reram_bitcell_7
Xbit_r20_c119 bl[119] br[119] wl[20] gnd reram_bitcell_7
Xbit_r21_c119 bl[119] br[119] wl[21] gnd reram_bitcell_7
Xbit_r22_c119 bl[119] br[119] wl[22] gnd reram_bitcell_7
Xbit_r23_c119 bl[119] br[119] wl[23] gnd reram_bitcell_7
Xbit_r24_c119 bl[119] br[119] wl[24] gnd reram_bitcell_7
Xbit_r25_c119 bl[119] br[119] wl[25] gnd reram_bitcell_7
Xbit_r26_c119 bl[119] br[119] wl[26] gnd reram_bitcell_7
Xbit_r27_c119 bl[119] br[119] wl[27] gnd reram_bitcell_7
Xbit_r28_c119 bl[119] br[119] wl[28] gnd reram_bitcell_7
Xbit_r29_c119 bl[119] br[119] wl[29] gnd reram_bitcell_7
Xbit_r30_c119 bl[119] br[119] wl[30] gnd reram_bitcell_7
Xbit_r31_c119 bl[119] br[119] wl[31] gnd reram_bitcell_7
Xbit_r32_c119 bl[119] br[119] wl[32] gnd reram_bitcell_7
Xbit_r33_c119 bl[119] br[119] wl[33] gnd reram_bitcell_7
Xbit_r34_c119 bl[119] br[119] wl[34] gnd reram_bitcell_7
Xbit_r35_c119 bl[119] br[119] wl[35] gnd reram_bitcell_7
Xbit_r36_c119 bl[119] br[119] wl[36] gnd reram_bitcell_7
Xbit_r37_c119 bl[119] br[119] wl[37] gnd reram_bitcell_7
Xbit_r38_c119 bl[119] br[119] wl[38] gnd reram_bitcell_7
Xbit_r39_c119 bl[119] br[119] wl[39] gnd reram_bitcell_7
Xbit_r40_c119 bl[119] br[119] wl[40] gnd reram_bitcell_7
Xbit_r41_c119 bl[119] br[119] wl[41] gnd reram_bitcell_7
Xbit_r42_c119 bl[119] br[119] wl[42] gnd reram_bitcell_7
Xbit_r43_c119 bl[119] br[119] wl[43] gnd reram_bitcell_7
Xbit_r44_c119 bl[119] br[119] wl[44] gnd reram_bitcell_7
Xbit_r45_c119 bl[119] br[119] wl[45] gnd reram_bitcell_7
Xbit_r46_c119 bl[119] br[119] wl[46] gnd reram_bitcell_7
Xbit_r47_c119 bl[119] br[119] wl[47] gnd reram_bitcell_7
Xbit_r48_c119 bl[119] br[119] wl[48] gnd reram_bitcell_7
Xbit_r49_c119 bl[119] br[119] wl[49] gnd reram_bitcell_7
Xbit_r50_c119 bl[119] br[119] wl[50] gnd reram_bitcell_7
Xbit_r51_c119 bl[119] br[119] wl[51] gnd reram_bitcell_7
Xbit_r52_c119 bl[119] br[119] wl[52] gnd reram_bitcell_7
Xbit_r53_c119 bl[119] br[119] wl[53] gnd reram_bitcell_7
Xbit_r54_c119 bl[119] br[119] wl[54] gnd reram_bitcell_7
Xbit_r55_c119 bl[119] br[119] wl[55] gnd reram_bitcell_7
Xbit_r56_c119 bl[119] br[119] wl[56] gnd reram_bitcell_7
Xbit_r57_c119 bl[119] br[119] wl[57] gnd reram_bitcell_7
Xbit_r58_c119 bl[119] br[119] wl[58] gnd reram_bitcell_7
Xbit_r59_c119 bl[119] br[119] wl[59] gnd reram_bitcell_7
Xbit_r60_c119 bl[119] br[119] wl[60] gnd reram_bitcell_7
Xbit_r61_c119 bl[119] br[119] wl[61] gnd reram_bitcell_7
Xbit_r62_c119 bl[119] br[119] wl[62] gnd reram_bitcell_7
Xbit_r63_c119 bl[119] br[119] wl[63] gnd reram_bitcell_7
Xbit_r0_c120 bl[120] br[120] wl[0] gnd reram_bitcell_7
Xbit_r1_c120 bl[120] br[120] wl[1] gnd reram_bitcell_7
Xbit_r2_c120 bl[120] br[120] wl[2] gnd reram_bitcell_7
Xbit_r3_c120 bl[120] br[120] wl[3] gnd reram_bitcell_7
Xbit_r4_c120 bl[120] br[120] wl[4] gnd reram_bitcell_7
Xbit_r5_c120 bl[120] br[120] wl[5] gnd reram_bitcell_7
Xbit_r6_c120 bl[120] br[120] wl[6] gnd reram_bitcell_7
Xbit_r7_c120 bl[120] br[120] wl[7] gnd reram_bitcell_7
Xbit_r8_c120 bl[120] br[120] wl[8] gnd reram_bitcell_7
Xbit_r9_c120 bl[120] br[120] wl[9] gnd reram_bitcell_7
Xbit_r10_c120 bl[120] br[120] wl[10] gnd reram_bitcell_7
Xbit_r11_c120 bl[120] br[120] wl[11] gnd reram_bitcell_7
Xbit_r12_c120 bl[120] br[120] wl[12] gnd reram_bitcell_7
Xbit_r13_c120 bl[120] br[120] wl[13] gnd reram_bitcell_7
Xbit_r14_c120 bl[120] br[120] wl[14] gnd reram_bitcell_7
Xbit_r15_c120 bl[120] br[120] wl[15] gnd reram_bitcell_7
Xbit_r16_c120 bl[120] br[120] wl[16] gnd reram_bitcell_7
Xbit_r17_c120 bl[120] br[120] wl[17] gnd reram_bitcell_7
Xbit_r18_c120 bl[120] br[120] wl[18] gnd reram_bitcell_7
Xbit_r19_c120 bl[120] br[120] wl[19] gnd reram_bitcell_7
Xbit_r20_c120 bl[120] br[120] wl[20] gnd reram_bitcell_7
Xbit_r21_c120 bl[120] br[120] wl[21] gnd reram_bitcell_7
Xbit_r22_c120 bl[120] br[120] wl[22] gnd reram_bitcell_7
Xbit_r23_c120 bl[120] br[120] wl[23] gnd reram_bitcell_7
Xbit_r24_c120 bl[120] br[120] wl[24] gnd reram_bitcell_7
Xbit_r25_c120 bl[120] br[120] wl[25] gnd reram_bitcell_7
Xbit_r26_c120 bl[120] br[120] wl[26] gnd reram_bitcell_7
Xbit_r27_c120 bl[120] br[120] wl[27] gnd reram_bitcell_7
Xbit_r28_c120 bl[120] br[120] wl[28] gnd reram_bitcell_7
Xbit_r29_c120 bl[120] br[120] wl[29] gnd reram_bitcell_7
Xbit_r30_c120 bl[120] br[120] wl[30] gnd reram_bitcell_7
Xbit_r31_c120 bl[120] br[120] wl[31] gnd reram_bitcell_7
Xbit_r32_c120 bl[120] br[120] wl[32] gnd reram_bitcell_7
Xbit_r33_c120 bl[120] br[120] wl[33] gnd reram_bitcell_7
Xbit_r34_c120 bl[120] br[120] wl[34] gnd reram_bitcell_7
Xbit_r35_c120 bl[120] br[120] wl[35] gnd reram_bitcell_7
Xbit_r36_c120 bl[120] br[120] wl[36] gnd reram_bitcell_7
Xbit_r37_c120 bl[120] br[120] wl[37] gnd reram_bitcell_7
Xbit_r38_c120 bl[120] br[120] wl[38] gnd reram_bitcell_7
Xbit_r39_c120 bl[120] br[120] wl[39] gnd reram_bitcell_7
Xbit_r40_c120 bl[120] br[120] wl[40] gnd reram_bitcell_7
Xbit_r41_c120 bl[120] br[120] wl[41] gnd reram_bitcell_7
Xbit_r42_c120 bl[120] br[120] wl[42] gnd reram_bitcell_7
Xbit_r43_c120 bl[120] br[120] wl[43] gnd reram_bitcell_7
Xbit_r44_c120 bl[120] br[120] wl[44] gnd reram_bitcell_7
Xbit_r45_c120 bl[120] br[120] wl[45] gnd reram_bitcell_7
Xbit_r46_c120 bl[120] br[120] wl[46] gnd reram_bitcell_7
Xbit_r47_c120 bl[120] br[120] wl[47] gnd reram_bitcell_7
Xbit_r48_c120 bl[120] br[120] wl[48] gnd reram_bitcell_7
Xbit_r49_c120 bl[120] br[120] wl[49] gnd reram_bitcell_7
Xbit_r50_c120 bl[120] br[120] wl[50] gnd reram_bitcell_7
Xbit_r51_c120 bl[120] br[120] wl[51] gnd reram_bitcell_7
Xbit_r52_c120 bl[120] br[120] wl[52] gnd reram_bitcell_7
Xbit_r53_c120 bl[120] br[120] wl[53] gnd reram_bitcell_7
Xbit_r54_c120 bl[120] br[120] wl[54] gnd reram_bitcell_7
Xbit_r55_c120 bl[120] br[120] wl[55] gnd reram_bitcell_7
Xbit_r56_c120 bl[120] br[120] wl[56] gnd reram_bitcell_7
Xbit_r57_c120 bl[120] br[120] wl[57] gnd reram_bitcell_7
Xbit_r58_c120 bl[120] br[120] wl[58] gnd reram_bitcell_7
Xbit_r59_c120 bl[120] br[120] wl[59] gnd reram_bitcell_7
Xbit_r60_c120 bl[120] br[120] wl[60] gnd reram_bitcell_7
Xbit_r61_c120 bl[120] br[120] wl[61] gnd reram_bitcell_7
Xbit_r62_c120 bl[120] br[120] wl[62] gnd reram_bitcell_7
Xbit_r63_c120 bl[120] br[120] wl[63] gnd reram_bitcell_7
Xbit_r0_c121 bl[121] br[121] wl[0] gnd reram_bitcell_7
Xbit_r1_c121 bl[121] br[121] wl[1] gnd reram_bitcell_7
Xbit_r2_c121 bl[121] br[121] wl[2] gnd reram_bitcell_7
Xbit_r3_c121 bl[121] br[121] wl[3] gnd reram_bitcell_7
Xbit_r4_c121 bl[121] br[121] wl[4] gnd reram_bitcell_7
Xbit_r5_c121 bl[121] br[121] wl[5] gnd reram_bitcell_7
Xbit_r6_c121 bl[121] br[121] wl[6] gnd reram_bitcell_7
Xbit_r7_c121 bl[121] br[121] wl[7] gnd reram_bitcell_7
Xbit_r8_c121 bl[121] br[121] wl[8] gnd reram_bitcell_7
Xbit_r9_c121 bl[121] br[121] wl[9] gnd reram_bitcell_7
Xbit_r10_c121 bl[121] br[121] wl[10] gnd reram_bitcell_7
Xbit_r11_c121 bl[121] br[121] wl[11] gnd reram_bitcell_7
Xbit_r12_c121 bl[121] br[121] wl[12] gnd reram_bitcell_7
Xbit_r13_c121 bl[121] br[121] wl[13] gnd reram_bitcell_7
Xbit_r14_c121 bl[121] br[121] wl[14] gnd reram_bitcell_7
Xbit_r15_c121 bl[121] br[121] wl[15] gnd reram_bitcell_7
Xbit_r16_c121 bl[121] br[121] wl[16] gnd reram_bitcell_7
Xbit_r17_c121 bl[121] br[121] wl[17] gnd reram_bitcell_7
Xbit_r18_c121 bl[121] br[121] wl[18] gnd reram_bitcell_7
Xbit_r19_c121 bl[121] br[121] wl[19] gnd reram_bitcell_7
Xbit_r20_c121 bl[121] br[121] wl[20] gnd reram_bitcell_7
Xbit_r21_c121 bl[121] br[121] wl[21] gnd reram_bitcell_7
Xbit_r22_c121 bl[121] br[121] wl[22] gnd reram_bitcell_7
Xbit_r23_c121 bl[121] br[121] wl[23] gnd reram_bitcell_7
Xbit_r24_c121 bl[121] br[121] wl[24] gnd reram_bitcell_7
Xbit_r25_c121 bl[121] br[121] wl[25] gnd reram_bitcell_7
Xbit_r26_c121 bl[121] br[121] wl[26] gnd reram_bitcell_7
Xbit_r27_c121 bl[121] br[121] wl[27] gnd reram_bitcell_7
Xbit_r28_c121 bl[121] br[121] wl[28] gnd reram_bitcell_7
Xbit_r29_c121 bl[121] br[121] wl[29] gnd reram_bitcell_7
Xbit_r30_c121 bl[121] br[121] wl[30] gnd reram_bitcell_7
Xbit_r31_c121 bl[121] br[121] wl[31] gnd reram_bitcell_7
Xbit_r32_c121 bl[121] br[121] wl[32] gnd reram_bitcell_7
Xbit_r33_c121 bl[121] br[121] wl[33] gnd reram_bitcell_7
Xbit_r34_c121 bl[121] br[121] wl[34] gnd reram_bitcell_7
Xbit_r35_c121 bl[121] br[121] wl[35] gnd reram_bitcell_7
Xbit_r36_c121 bl[121] br[121] wl[36] gnd reram_bitcell_7
Xbit_r37_c121 bl[121] br[121] wl[37] gnd reram_bitcell_7
Xbit_r38_c121 bl[121] br[121] wl[38] gnd reram_bitcell_7
Xbit_r39_c121 bl[121] br[121] wl[39] gnd reram_bitcell_7
Xbit_r40_c121 bl[121] br[121] wl[40] gnd reram_bitcell_7
Xbit_r41_c121 bl[121] br[121] wl[41] gnd reram_bitcell_7
Xbit_r42_c121 bl[121] br[121] wl[42] gnd reram_bitcell_7
Xbit_r43_c121 bl[121] br[121] wl[43] gnd reram_bitcell_7
Xbit_r44_c121 bl[121] br[121] wl[44] gnd reram_bitcell_7
Xbit_r45_c121 bl[121] br[121] wl[45] gnd reram_bitcell_7
Xbit_r46_c121 bl[121] br[121] wl[46] gnd reram_bitcell_7
Xbit_r47_c121 bl[121] br[121] wl[47] gnd reram_bitcell_7
Xbit_r48_c121 bl[121] br[121] wl[48] gnd reram_bitcell_7
Xbit_r49_c121 bl[121] br[121] wl[49] gnd reram_bitcell_7
Xbit_r50_c121 bl[121] br[121] wl[50] gnd reram_bitcell_7
Xbit_r51_c121 bl[121] br[121] wl[51] gnd reram_bitcell_7
Xbit_r52_c121 bl[121] br[121] wl[52] gnd reram_bitcell_7
Xbit_r53_c121 bl[121] br[121] wl[53] gnd reram_bitcell_7
Xbit_r54_c121 bl[121] br[121] wl[54] gnd reram_bitcell_7
Xbit_r55_c121 bl[121] br[121] wl[55] gnd reram_bitcell_7
Xbit_r56_c121 bl[121] br[121] wl[56] gnd reram_bitcell_7
Xbit_r57_c121 bl[121] br[121] wl[57] gnd reram_bitcell_7
Xbit_r58_c121 bl[121] br[121] wl[58] gnd reram_bitcell_7
Xbit_r59_c121 bl[121] br[121] wl[59] gnd reram_bitcell_7
Xbit_r60_c121 bl[121] br[121] wl[60] gnd reram_bitcell_7
Xbit_r61_c121 bl[121] br[121] wl[61] gnd reram_bitcell_7
Xbit_r62_c121 bl[121] br[121] wl[62] gnd reram_bitcell_7
Xbit_r63_c121 bl[121] br[121] wl[63] gnd reram_bitcell_7
Xbit_r0_c122 bl[122] br[122] wl[0] gnd reram_bitcell_7
Xbit_r1_c122 bl[122] br[122] wl[1] gnd reram_bitcell_7
Xbit_r2_c122 bl[122] br[122] wl[2] gnd reram_bitcell_7
Xbit_r3_c122 bl[122] br[122] wl[3] gnd reram_bitcell_7
Xbit_r4_c122 bl[122] br[122] wl[4] gnd reram_bitcell_7
Xbit_r5_c122 bl[122] br[122] wl[5] gnd reram_bitcell_7
Xbit_r6_c122 bl[122] br[122] wl[6] gnd reram_bitcell_7
Xbit_r7_c122 bl[122] br[122] wl[7] gnd reram_bitcell_7
Xbit_r8_c122 bl[122] br[122] wl[8] gnd reram_bitcell_7
Xbit_r9_c122 bl[122] br[122] wl[9] gnd reram_bitcell_7
Xbit_r10_c122 bl[122] br[122] wl[10] gnd reram_bitcell_7
Xbit_r11_c122 bl[122] br[122] wl[11] gnd reram_bitcell_7
Xbit_r12_c122 bl[122] br[122] wl[12] gnd reram_bitcell_7
Xbit_r13_c122 bl[122] br[122] wl[13] gnd reram_bitcell_7
Xbit_r14_c122 bl[122] br[122] wl[14] gnd reram_bitcell_7
Xbit_r15_c122 bl[122] br[122] wl[15] gnd reram_bitcell_7
Xbit_r16_c122 bl[122] br[122] wl[16] gnd reram_bitcell_7
Xbit_r17_c122 bl[122] br[122] wl[17] gnd reram_bitcell_7
Xbit_r18_c122 bl[122] br[122] wl[18] gnd reram_bitcell_7
Xbit_r19_c122 bl[122] br[122] wl[19] gnd reram_bitcell_7
Xbit_r20_c122 bl[122] br[122] wl[20] gnd reram_bitcell_7
Xbit_r21_c122 bl[122] br[122] wl[21] gnd reram_bitcell_7
Xbit_r22_c122 bl[122] br[122] wl[22] gnd reram_bitcell_7
Xbit_r23_c122 bl[122] br[122] wl[23] gnd reram_bitcell_7
Xbit_r24_c122 bl[122] br[122] wl[24] gnd reram_bitcell_7
Xbit_r25_c122 bl[122] br[122] wl[25] gnd reram_bitcell_7
Xbit_r26_c122 bl[122] br[122] wl[26] gnd reram_bitcell_7
Xbit_r27_c122 bl[122] br[122] wl[27] gnd reram_bitcell_7
Xbit_r28_c122 bl[122] br[122] wl[28] gnd reram_bitcell_7
Xbit_r29_c122 bl[122] br[122] wl[29] gnd reram_bitcell_7
Xbit_r30_c122 bl[122] br[122] wl[30] gnd reram_bitcell_7
Xbit_r31_c122 bl[122] br[122] wl[31] gnd reram_bitcell_7
Xbit_r32_c122 bl[122] br[122] wl[32] gnd reram_bitcell_7
Xbit_r33_c122 bl[122] br[122] wl[33] gnd reram_bitcell_7
Xbit_r34_c122 bl[122] br[122] wl[34] gnd reram_bitcell_7
Xbit_r35_c122 bl[122] br[122] wl[35] gnd reram_bitcell_7
Xbit_r36_c122 bl[122] br[122] wl[36] gnd reram_bitcell_7
Xbit_r37_c122 bl[122] br[122] wl[37] gnd reram_bitcell_7
Xbit_r38_c122 bl[122] br[122] wl[38] gnd reram_bitcell_7
Xbit_r39_c122 bl[122] br[122] wl[39] gnd reram_bitcell_7
Xbit_r40_c122 bl[122] br[122] wl[40] gnd reram_bitcell_7
Xbit_r41_c122 bl[122] br[122] wl[41] gnd reram_bitcell_7
Xbit_r42_c122 bl[122] br[122] wl[42] gnd reram_bitcell_7
Xbit_r43_c122 bl[122] br[122] wl[43] gnd reram_bitcell_7
Xbit_r44_c122 bl[122] br[122] wl[44] gnd reram_bitcell_7
Xbit_r45_c122 bl[122] br[122] wl[45] gnd reram_bitcell_7
Xbit_r46_c122 bl[122] br[122] wl[46] gnd reram_bitcell_7
Xbit_r47_c122 bl[122] br[122] wl[47] gnd reram_bitcell_7
Xbit_r48_c122 bl[122] br[122] wl[48] gnd reram_bitcell_7
Xbit_r49_c122 bl[122] br[122] wl[49] gnd reram_bitcell_7
Xbit_r50_c122 bl[122] br[122] wl[50] gnd reram_bitcell_7
Xbit_r51_c122 bl[122] br[122] wl[51] gnd reram_bitcell_7
Xbit_r52_c122 bl[122] br[122] wl[52] gnd reram_bitcell_7
Xbit_r53_c122 bl[122] br[122] wl[53] gnd reram_bitcell_7
Xbit_r54_c122 bl[122] br[122] wl[54] gnd reram_bitcell_7
Xbit_r55_c122 bl[122] br[122] wl[55] gnd reram_bitcell_7
Xbit_r56_c122 bl[122] br[122] wl[56] gnd reram_bitcell_7
Xbit_r57_c122 bl[122] br[122] wl[57] gnd reram_bitcell_7
Xbit_r58_c122 bl[122] br[122] wl[58] gnd reram_bitcell_7
Xbit_r59_c122 bl[122] br[122] wl[59] gnd reram_bitcell_7
Xbit_r60_c122 bl[122] br[122] wl[60] gnd reram_bitcell_7
Xbit_r61_c122 bl[122] br[122] wl[61] gnd reram_bitcell_7
Xbit_r62_c122 bl[122] br[122] wl[62] gnd reram_bitcell_7
Xbit_r63_c122 bl[122] br[122] wl[63] gnd reram_bitcell_7
Xbit_r0_c123 bl[123] br[123] wl[0] gnd reram_bitcell_7
Xbit_r1_c123 bl[123] br[123] wl[1] gnd reram_bitcell_7
Xbit_r2_c123 bl[123] br[123] wl[2] gnd reram_bitcell_7
Xbit_r3_c123 bl[123] br[123] wl[3] gnd reram_bitcell_7
Xbit_r4_c123 bl[123] br[123] wl[4] gnd reram_bitcell_7
Xbit_r5_c123 bl[123] br[123] wl[5] gnd reram_bitcell_7
Xbit_r6_c123 bl[123] br[123] wl[6] gnd reram_bitcell_7
Xbit_r7_c123 bl[123] br[123] wl[7] gnd reram_bitcell_7
Xbit_r8_c123 bl[123] br[123] wl[8] gnd reram_bitcell_7
Xbit_r9_c123 bl[123] br[123] wl[9] gnd reram_bitcell_7
Xbit_r10_c123 bl[123] br[123] wl[10] gnd reram_bitcell_7
Xbit_r11_c123 bl[123] br[123] wl[11] gnd reram_bitcell_7
Xbit_r12_c123 bl[123] br[123] wl[12] gnd reram_bitcell_7
Xbit_r13_c123 bl[123] br[123] wl[13] gnd reram_bitcell_7
Xbit_r14_c123 bl[123] br[123] wl[14] gnd reram_bitcell_7
Xbit_r15_c123 bl[123] br[123] wl[15] gnd reram_bitcell_7
Xbit_r16_c123 bl[123] br[123] wl[16] gnd reram_bitcell_7
Xbit_r17_c123 bl[123] br[123] wl[17] gnd reram_bitcell_7
Xbit_r18_c123 bl[123] br[123] wl[18] gnd reram_bitcell_7
Xbit_r19_c123 bl[123] br[123] wl[19] gnd reram_bitcell_7
Xbit_r20_c123 bl[123] br[123] wl[20] gnd reram_bitcell_7
Xbit_r21_c123 bl[123] br[123] wl[21] gnd reram_bitcell_7
Xbit_r22_c123 bl[123] br[123] wl[22] gnd reram_bitcell_7
Xbit_r23_c123 bl[123] br[123] wl[23] gnd reram_bitcell_7
Xbit_r24_c123 bl[123] br[123] wl[24] gnd reram_bitcell_7
Xbit_r25_c123 bl[123] br[123] wl[25] gnd reram_bitcell_7
Xbit_r26_c123 bl[123] br[123] wl[26] gnd reram_bitcell_7
Xbit_r27_c123 bl[123] br[123] wl[27] gnd reram_bitcell_7
Xbit_r28_c123 bl[123] br[123] wl[28] gnd reram_bitcell_7
Xbit_r29_c123 bl[123] br[123] wl[29] gnd reram_bitcell_7
Xbit_r30_c123 bl[123] br[123] wl[30] gnd reram_bitcell_7
Xbit_r31_c123 bl[123] br[123] wl[31] gnd reram_bitcell_7
Xbit_r32_c123 bl[123] br[123] wl[32] gnd reram_bitcell_7
Xbit_r33_c123 bl[123] br[123] wl[33] gnd reram_bitcell_7
Xbit_r34_c123 bl[123] br[123] wl[34] gnd reram_bitcell_7
Xbit_r35_c123 bl[123] br[123] wl[35] gnd reram_bitcell_7
Xbit_r36_c123 bl[123] br[123] wl[36] gnd reram_bitcell_7
Xbit_r37_c123 bl[123] br[123] wl[37] gnd reram_bitcell_7
Xbit_r38_c123 bl[123] br[123] wl[38] gnd reram_bitcell_7
Xbit_r39_c123 bl[123] br[123] wl[39] gnd reram_bitcell_7
Xbit_r40_c123 bl[123] br[123] wl[40] gnd reram_bitcell_7
Xbit_r41_c123 bl[123] br[123] wl[41] gnd reram_bitcell_7
Xbit_r42_c123 bl[123] br[123] wl[42] gnd reram_bitcell_7
Xbit_r43_c123 bl[123] br[123] wl[43] gnd reram_bitcell_7
Xbit_r44_c123 bl[123] br[123] wl[44] gnd reram_bitcell_7
Xbit_r45_c123 bl[123] br[123] wl[45] gnd reram_bitcell_7
Xbit_r46_c123 bl[123] br[123] wl[46] gnd reram_bitcell_7
Xbit_r47_c123 bl[123] br[123] wl[47] gnd reram_bitcell_7
Xbit_r48_c123 bl[123] br[123] wl[48] gnd reram_bitcell_7
Xbit_r49_c123 bl[123] br[123] wl[49] gnd reram_bitcell_7
Xbit_r50_c123 bl[123] br[123] wl[50] gnd reram_bitcell_7
Xbit_r51_c123 bl[123] br[123] wl[51] gnd reram_bitcell_7
Xbit_r52_c123 bl[123] br[123] wl[52] gnd reram_bitcell_7
Xbit_r53_c123 bl[123] br[123] wl[53] gnd reram_bitcell_7
Xbit_r54_c123 bl[123] br[123] wl[54] gnd reram_bitcell_7
Xbit_r55_c123 bl[123] br[123] wl[55] gnd reram_bitcell_7
Xbit_r56_c123 bl[123] br[123] wl[56] gnd reram_bitcell_7
Xbit_r57_c123 bl[123] br[123] wl[57] gnd reram_bitcell_7
Xbit_r58_c123 bl[123] br[123] wl[58] gnd reram_bitcell_7
Xbit_r59_c123 bl[123] br[123] wl[59] gnd reram_bitcell_7
Xbit_r60_c123 bl[123] br[123] wl[60] gnd reram_bitcell_7
Xbit_r61_c123 bl[123] br[123] wl[61] gnd reram_bitcell_7
Xbit_r62_c123 bl[123] br[123] wl[62] gnd reram_bitcell_7
Xbit_r63_c123 bl[123] br[123] wl[63] gnd reram_bitcell_7
Xbit_r0_c124 bl[124] br[124] wl[0] gnd reram_bitcell_7
Xbit_r1_c124 bl[124] br[124] wl[1] gnd reram_bitcell_7
Xbit_r2_c124 bl[124] br[124] wl[2] gnd reram_bitcell_7
Xbit_r3_c124 bl[124] br[124] wl[3] gnd reram_bitcell_7
Xbit_r4_c124 bl[124] br[124] wl[4] gnd reram_bitcell_7
Xbit_r5_c124 bl[124] br[124] wl[5] gnd reram_bitcell_7
Xbit_r6_c124 bl[124] br[124] wl[6] gnd reram_bitcell_7
Xbit_r7_c124 bl[124] br[124] wl[7] gnd reram_bitcell_7
Xbit_r8_c124 bl[124] br[124] wl[8] gnd reram_bitcell_7
Xbit_r9_c124 bl[124] br[124] wl[9] gnd reram_bitcell_7
Xbit_r10_c124 bl[124] br[124] wl[10] gnd reram_bitcell_7
Xbit_r11_c124 bl[124] br[124] wl[11] gnd reram_bitcell_7
Xbit_r12_c124 bl[124] br[124] wl[12] gnd reram_bitcell_7
Xbit_r13_c124 bl[124] br[124] wl[13] gnd reram_bitcell_7
Xbit_r14_c124 bl[124] br[124] wl[14] gnd reram_bitcell_7
Xbit_r15_c124 bl[124] br[124] wl[15] gnd reram_bitcell_7
Xbit_r16_c124 bl[124] br[124] wl[16] gnd reram_bitcell_7
Xbit_r17_c124 bl[124] br[124] wl[17] gnd reram_bitcell_7
Xbit_r18_c124 bl[124] br[124] wl[18] gnd reram_bitcell_7
Xbit_r19_c124 bl[124] br[124] wl[19] gnd reram_bitcell_7
Xbit_r20_c124 bl[124] br[124] wl[20] gnd reram_bitcell_7
Xbit_r21_c124 bl[124] br[124] wl[21] gnd reram_bitcell_7
Xbit_r22_c124 bl[124] br[124] wl[22] gnd reram_bitcell_7
Xbit_r23_c124 bl[124] br[124] wl[23] gnd reram_bitcell_7
Xbit_r24_c124 bl[124] br[124] wl[24] gnd reram_bitcell_7
Xbit_r25_c124 bl[124] br[124] wl[25] gnd reram_bitcell_7
Xbit_r26_c124 bl[124] br[124] wl[26] gnd reram_bitcell_7
Xbit_r27_c124 bl[124] br[124] wl[27] gnd reram_bitcell_7
Xbit_r28_c124 bl[124] br[124] wl[28] gnd reram_bitcell_7
Xbit_r29_c124 bl[124] br[124] wl[29] gnd reram_bitcell_7
Xbit_r30_c124 bl[124] br[124] wl[30] gnd reram_bitcell_7
Xbit_r31_c124 bl[124] br[124] wl[31] gnd reram_bitcell_7
Xbit_r32_c124 bl[124] br[124] wl[32] gnd reram_bitcell_7
Xbit_r33_c124 bl[124] br[124] wl[33] gnd reram_bitcell_7
Xbit_r34_c124 bl[124] br[124] wl[34] gnd reram_bitcell_7
Xbit_r35_c124 bl[124] br[124] wl[35] gnd reram_bitcell_7
Xbit_r36_c124 bl[124] br[124] wl[36] gnd reram_bitcell_7
Xbit_r37_c124 bl[124] br[124] wl[37] gnd reram_bitcell_7
Xbit_r38_c124 bl[124] br[124] wl[38] gnd reram_bitcell_7
Xbit_r39_c124 bl[124] br[124] wl[39] gnd reram_bitcell_7
Xbit_r40_c124 bl[124] br[124] wl[40] gnd reram_bitcell_7
Xbit_r41_c124 bl[124] br[124] wl[41] gnd reram_bitcell_7
Xbit_r42_c124 bl[124] br[124] wl[42] gnd reram_bitcell_7
Xbit_r43_c124 bl[124] br[124] wl[43] gnd reram_bitcell_7
Xbit_r44_c124 bl[124] br[124] wl[44] gnd reram_bitcell_7
Xbit_r45_c124 bl[124] br[124] wl[45] gnd reram_bitcell_7
Xbit_r46_c124 bl[124] br[124] wl[46] gnd reram_bitcell_7
Xbit_r47_c124 bl[124] br[124] wl[47] gnd reram_bitcell_7
Xbit_r48_c124 bl[124] br[124] wl[48] gnd reram_bitcell_7
Xbit_r49_c124 bl[124] br[124] wl[49] gnd reram_bitcell_7
Xbit_r50_c124 bl[124] br[124] wl[50] gnd reram_bitcell_7
Xbit_r51_c124 bl[124] br[124] wl[51] gnd reram_bitcell_7
Xbit_r52_c124 bl[124] br[124] wl[52] gnd reram_bitcell_7
Xbit_r53_c124 bl[124] br[124] wl[53] gnd reram_bitcell_7
Xbit_r54_c124 bl[124] br[124] wl[54] gnd reram_bitcell_7
Xbit_r55_c124 bl[124] br[124] wl[55] gnd reram_bitcell_7
Xbit_r56_c124 bl[124] br[124] wl[56] gnd reram_bitcell_7
Xbit_r57_c124 bl[124] br[124] wl[57] gnd reram_bitcell_7
Xbit_r58_c124 bl[124] br[124] wl[58] gnd reram_bitcell_7
Xbit_r59_c124 bl[124] br[124] wl[59] gnd reram_bitcell_7
Xbit_r60_c124 bl[124] br[124] wl[60] gnd reram_bitcell_7
Xbit_r61_c124 bl[124] br[124] wl[61] gnd reram_bitcell_7
Xbit_r62_c124 bl[124] br[124] wl[62] gnd reram_bitcell_7
Xbit_r63_c124 bl[124] br[124] wl[63] gnd reram_bitcell_7
Xbit_r0_c125 bl[125] br[125] wl[0] gnd reram_bitcell_7
Xbit_r1_c125 bl[125] br[125] wl[1] gnd reram_bitcell_7
Xbit_r2_c125 bl[125] br[125] wl[2] gnd reram_bitcell_7
Xbit_r3_c125 bl[125] br[125] wl[3] gnd reram_bitcell_7
Xbit_r4_c125 bl[125] br[125] wl[4] gnd reram_bitcell_7
Xbit_r5_c125 bl[125] br[125] wl[5] gnd reram_bitcell_7
Xbit_r6_c125 bl[125] br[125] wl[6] gnd reram_bitcell_7
Xbit_r7_c125 bl[125] br[125] wl[7] gnd reram_bitcell_7
Xbit_r8_c125 bl[125] br[125] wl[8] gnd reram_bitcell_7
Xbit_r9_c125 bl[125] br[125] wl[9] gnd reram_bitcell_7
Xbit_r10_c125 bl[125] br[125] wl[10] gnd reram_bitcell_7
Xbit_r11_c125 bl[125] br[125] wl[11] gnd reram_bitcell_7
Xbit_r12_c125 bl[125] br[125] wl[12] gnd reram_bitcell_7
Xbit_r13_c125 bl[125] br[125] wl[13] gnd reram_bitcell_7
Xbit_r14_c125 bl[125] br[125] wl[14] gnd reram_bitcell_7
Xbit_r15_c125 bl[125] br[125] wl[15] gnd reram_bitcell_7
Xbit_r16_c125 bl[125] br[125] wl[16] gnd reram_bitcell_7
Xbit_r17_c125 bl[125] br[125] wl[17] gnd reram_bitcell_7
Xbit_r18_c125 bl[125] br[125] wl[18] gnd reram_bitcell_7
Xbit_r19_c125 bl[125] br[125] wl[19] gnd reram_bitcell_7
Xbit_r20_c125 bl[125] br[125] wl[20] gnd reram_bitcell_7
Xbit_r21_c125 bl[125] br[125] wl[21] gnd reram_bitcell_7
Xbit_r22_c125 bl[125] br[125] wl[22] gnd reram_bitcell_7
Xbit_r23_c125 bl[125] br[125] wl[23] gnd reram_bitcell_7
Xbit_r24_c125 bl[125] br[125] wl[24] gnd reram_bitcell_7
Xbit_r25_c125 bl[125] br[125] wl[25] gnd reram_bitcell_7
Xbit_r26_c125 bl[125] br[125] wl[26] gnd reram_bitcell_7
Xbit_r27_c125 bl[125] br[125] wl[27] gnd reram_bitcell_7
Xbit_r28_c125 bl[125] br[125] wl[28] gnd reram_bitcell_7
Xbit_r29_c125 bl[125] br[125] wl[29] gnd reram_bitcell_7
Xbit_r30_c125 bl[125] br[125] wl[30] gnd reram_bitcell_7
Xbit_r31_c125 bl[125] br[125] wl[31] gnd reram_bitcell_7
Xbit_r32_c125 bl[125] br[125] wl[32] gnd reram_bitcell_7
Xbit_r33_c125 bl[125] br[125] wl[33] gnd reram_bitcell_7
Xbit_r34_c125 bl[125] br[125] wl[34] gnd reram_bitcell_7
Xbit_r35_c125 bl[125] br[125] wl[35] gnd reram_bitcell_7
Xbit_r36_c125 bl[125] br[125] wl[36] gnd reram_bitcell_7
Xbit_r37_c125 bl[125] br[125] wl[37] gnd reram_bitcell_7
Xbit_r38_c125 bl[125] br[125] wl[38] gnd reram_bitcell_7
Xbit_r39_c125 bl[125] br[125] wl[39] gnd reram_bitcell_7
Xbit_r40_c125 bl[125] br[125] wl[40] gnd reram_bitcell_7
Xbit_r41_c125 bl[125] br[125] wl[41] gnd reram_bitcell_7
Xbit_r42_c125 bl[125] br[125] wl[42] gnd reram_bitcell_7
Xbit_r43_c125 bl[125] br[125] wl[43] gnd reram_bitcell_7
Xbit_r44_c125 bl[125] br[125] wl[44] gnd reram_bitcell_7
Xbit_r45_c125 bl[125] br[125] wl[45] gnd reram_bitcell_7
Xbit_r46_c125 bl[125] br[125] wl[46] gnd reram_bitcell_7
Xbit_r47_c125 bl[125] br[125] wl[47] gnd reram_bitcell_7
Xbit_r48_c125 bl[125] br[125] wl[48] gnd reram_bitcell_7
Xbit_r49_c125 bl[125] br[125] wl[49] gnd reram_bitcell_7
Xbit_r50_c125 bl[125] br[125] wl[50] gnd reram_bitcell_7
Xbit_r51_c125 bl[125] br[125] wl[51] gnd reram_bitcell_7
Xbit_r52_c125 bl[125] br[125] wl[52] gnd reram_bitcell_7
Xbit_r53_c125 bl[125] br[125] wl[53] gnd reram_bitcell_7
Xbit_r54_c125 bl[125] br[125] wl[54] gnd reram_bitcell_7
Xbit_r55_c125 bl[125] br[125] wl[55] gnd reram_bitcell_7
Xbit_r56_c125 bl[125] br[125] wl[56] gnd reram_bitcell_7
Xbit_r57_c125 bl[125] br[125] wl[57] gnd reram_bitcell_7
Xbit_r58_c125 bl[125] br[125] wl[58] gnd reram_bitcell_7
Xbit_r59_c125 bl[125] br[125] wl[59] gnd reram_bitcell_7
Xbit_r60_c125 bl[125] br[125] wl[60] gnd reram_bitcell_7
Xbit_r61_c125 bl[125] br[125] wl[61] gnd reram_bitcell_7
Xbit_r62_c125 bl[125] br[125] wl[62] gnd reram_bitcell_7
Xbit_r63_c125 bl[125] br[125] wl[63] gnd reram_bitcell_7
Xbit_r0_c126 bl[126] br[126] wl[0] gnd reram_bitcell_7
Xbit_r1_c126 bl[126] br[126] wl[1] gnd reram_bitcell_7
Xbit_r2_c126 bl[126] br[126] wl[2] gnd reram_bitcell_7
Xbit_r3_c126 bl[126] br[126] wl[3] gnd reram_bitcell_7
Xbit_r4_c126 bl[126] br[126] wl[4] gnd reram_bitcell_7
Xbit_r5_c126 bl[126] br[126] wl[5] gnd reram_bitcell_7
Xbit_r6_c126 bl[126] br[126] wl[6] gnd reram_bitcell_7
Xbit_r7_c126 bl[126] br[126] wl[7] gnd reram_bitcell_7
Xbit_r8_c126 bl[126] br[126] wl[8] gnd reram_bitcell_7
Xbit_r9_c126 bl[126] br[126] wl[9] gnd reram_bitcell_7
Xbit_r10_c126 bl[126] br[126] wl[10] gnd reram_bitcell_7
Xbit_r11_c126 bl[126] br[126] wl[11] gnd reram_bitcell_7
Xbit_r12_c126 bl[126] br[126] wl[12] gnd reram_bitcell_7
Xbit_r13_c126 bl[126] br[126] wl[13] gnd reram_bitcell_7
Xbit_r14_c126 bl[126] br[126] wl[14] gnd reram_bitcell_7
Xbit_r15_c126 bl[126] br[126] wl[15] gnd reram_bitcell_7
Xbit_r16_c126 bl[126] br[126] wl[16] gnd reram_bitcell_7
Xbit_r17_c126 bl[126] br[126] wl[17] gnd reram_bitcell_7
Xbit_r18_c126 bl[126] br[126] wl[18] gnd reram_bitcell_7
Xbit_r19_c126 bl[126] br[126] wl[19] gnd reram_bitcell_7
Xbit_r20_c126 bl[126] br[126] wl[20] gnd reram_bitcell_7
Xbit_r21_c126 bl[126] br[126] wl[21] gnd reram_bitcell_7
Xbit_r22_c126 bl[126] br[126] wl[22] gnd reram_bitcell_7
Xbit_r23_c126 bl[126] br[126] wl[23] gnd reram_bitcell_7
Xbit_r24_c126 bl[126] br[126] wl[24] gnd reram_bitcell_7
Xbit_r25_c126 bl[126] br[126] wl[25] gnd reram_bitcell_7
Xbit_r26_c126 bl[126] br[126] wl[26] gnd reram_bitcell_7
Xbit_r27_c126 bl[126] br[126] wl[27] gnd reram_bitcell_7
Xbit_r28_c126 bl[126] br[126] wl[28] gnd reram_bitcell_7
Xbit_r29_c126 bl[126] br[126] wl[29] gnd reram_bitcell_7
Xbit_r30_c126 bl[126] br[126] wl[30] gnd reram_bitcell_7
Xbit_r31_c126 bl[126] br[126] wl[31] gnd reram_bitcell_7
Xbit_r32_c126 bl[126] br[126] wl[32] gnd reram_bitcell_7
Xbit_r33_c126 bl[126] br[126] wl[33] gnd reram_bitcell_7
Xbit_r34_c126 bl[126] br[126] wl[34] gnd reram_bitcell_7
Xbit_r35_c126 bl[126] br[126] wl[35] gnd reram_bitcell_7
Xbit_r36_c126 bl[126] br[126] wl[36] gnd reram_bitcell_7
Xbit_r37_c126 bl[126] br[126] wl[37] gnd reram_bitcell_7
Xbit_r38_c126 bl[126] br[126] wl[38] gnd reram_bitcell_7
Xbit_r39_c126 bl[126] br[126] wl[39] gnd reram_bitcell_7
Xbit_r40_c126 bl[126] br[126] wl[40] gnd reram_bitcell_7
Xbit_r41_c126 bl[126] br[126] wl[41] gnd reram_bitcell_7
Xbit_r42_c126 bl[126] br[126] wl[42] gnd reram_bitcell_7
Xbit_r43_c126 bl[126] br[126] wl[43] gnd reram_bitcell_7
Xbit_r44_c126 bl[126] br[126] wl[44] gnd reram_bitcell_7
Xbit_r45_c126 bl[126] br[126] wl[45] gnd reram_bitcell_7
Xbit_r46_c126 bl[126] br[126] wl[46] gnd reram_bitcell_7
Xbit_r47_c126 bl[126] br[126] wl[47] gnd reram_bitcell_7
Xbit_r48_c126 bl[126] br[126] wl[48] gnd reram_bitcell_7
Xbit_r49_c126 bl[126] br[126] wl[49] gnd reram_bitcell_7
Xbit_r50_c126 bl[126] br[126] wl[50] gnd reram_bitcell_7
Xbit_r51_c126 bl[126] br[126] wl[51] gnd reram_bitcell_7
Xbit_r52_c126 bl[126] br[126] wl[52] gnd reram_bitcell_7
Xbit_r53_c126 bl[126] br[126] wl[53] gnd reram_bitcell_7
Xbit_r54_c126 bl[126] br[126] wl[54] gnd reram_bitcell_7
Xbit_r55_c126 bl[126] br[126] wl[55] gnd reram_bitcell_7
Xbit_r56_c126 bl[126] br[126] wl[56] gnd reram_bitcell_7
Xbit_r57_c126 bl[126] br[126] wl[57] gnd reram_bitcell_7
Xbit_r58_c126 bl[126] br[126] wl[58] gnd reram_bitcell_7
Xbit_r59_c126 bl[126] br[126] wl[59] gnd reram_bitcell_7
Xbit_r60_c126 bl[126] br[126] wl[60] gnd reram_bitcell_7
Xbit_r61_c126 bl[126] br[126] wl[61] gnd reram_bitcell_7
Xbit_r62_c126 bl[126] br[126] wl[62] gnd reram_bitcell_7
Xbit_r63_c126 bl[126] br[126] wl[63] gnd reram_bitcell_7
Xbit_r0_c127 bl[127] br[127] wl[0] gnd reram_bitcell_7
Xbit_r1_c127 bl[127] br[127] wl[1] gnd reram_bitcell_7
Xbit_r2_c127 bl[127] br[127] wl[2] gnd reram_bitcell_7
Xbit_r3_c127 bl[127] br[127] wl[3] gnd reram_bitcell_7
Xbit_r4_c127 bl[127] br[127] wl[4] gnd reram_bitcell_7
Xbit_r5_c127 bl[127] br[127] wl[5] gnd reram_bitcell_7
Xbit_r6_c127 bl[127] br[127] wl[6] gnd reram_bitcell_7
Xbit_r7_c127 bl[127] br[127] wl[7] gnd reram_bitcell_7
Xbit_r8_c127 bl[127] br[127] wl[8] gnd reram_bitcell_7
Xbit_r9_c127 bl[127] br[127] wl[9] gnd reram_bitcell_7
Xbit_r10_c127 bl[127] br[127] wl[10] gnd reram_bitcell_7
Xbit_r11_c127 bl[127] br[127] wl[11] gnd reram_bitcell_7
Xbit_r12_c127 bl[127] br[127] wl[12] gnd reram_bitcell_7
Xbit_r13_c127 bl[127] br[127] wl[13] gnd reram_bitcell_7
Xbit_r14_c127 bl[127] br[127] wl[14] gnd reram_bitcell_7
Xbit_r15_c127 bl[127] br[127] wl[15] gnd reram_bitcell_7
Xbit_r16_c127 bl[127] br[127] wl[16] gnd reram_bitcell_7
Xbit_r17_c127 bl[127] br[127] wl[17] gnd reram_bitcell_7
Xbit_r18_c127 bl[127] br[127] wl[18] gnd reram_bitcell_7
Xbit_r19_c127 bl[127] br[127] wl[19] gnd reram_bitcell_7
Xbit_r20_c127 bl[127] br[127] wl[20] gnd reram_bitcell_7
Xbit_r21_c127 bl[127] br[127] wl[21] gnd reram_bitcell_7
Xbit_r22_c127 bl[127] br[127] wl[22] gnd reram_bitcell_7
Xbit_r23_c127 bl[127] br[127] wl[23] gnd reram_bitcell_7
Xbit_r24_c127 bl[127] br[127] wl[24] gnd reram_bitcell_7
Xbit_r25_c127 bl[127] br[127] wl[25] gnd reram_bitcell_7
Xbit_r26_c127 bl[127] br[127] wl[26] gnd reram_bitcell_7
Xbit_r27_c127 bl[127] br[127] wl[27] gnd reram_bitcell_7
Xbit_r28_c127 bl[127] br[127] wl[28] gnd reram_bitcell_7
Xbit_r29_c127 bl[127] br[127] wl[29] gnd reram_bitcell_7
Xbit_r30_c127 bl[127] br[127] wl[30] gnd reram_bitcell_7
Xbit_r31_c127 bl[127] br[127] wl[31] gnd reram_bitcell_7
Xbit_r32_c127 bl[127] br[127] wl[32] gnd reram_bitcell_7
Xbit_r33_c127 bl[127] br[127] wl[33] gnd reram_bitcell_7
Xbit_r34_c127 bl[127] br[127] wl[34] gnd reram_bitcell_7
Xbit_r35_c127 bl[127] br[127] wl[35] gnd reram_bitcell_7
Xbit_r36_c127 bl[127] br[127] wl[36] gnd reram_bitcell_7
Xbit_r37_c127 bl[127] br[127] wl[37] gnd reram_bitcell_7
Xbit_r38_c127 bl[127] br[127] wl[38] gnd reram_bitcell_7
Xbit_r39_c127 bl[127] br[127] wl[39] gnd reram_bitcell_7
Xbit_r40_c127 bl[127] br[127] wl[40] gnd reram_bitcell_7
Xbit_r41_c127 bl[127] br[127] wl[41] gnd reram_bitcell_7
Xbit_r42_c127 bl[127] br[127] wl[42] gnd reram_bitcell_7
Xbit_r43_c127 bl[127] br[127] wl[43] gnd reram_bitcell_7
Xbit_r44_c127 bl[127] br[127] wl[44] gnd reram_bitcell_7
Xbit_r45_c127 bl[127] br[127] wl[45] gnd reram_bitcell_7
Xbit_r46_c127 bl[127] br[127] wl[46] gnd reram_bitcell_7
Xbit_r47_c127 bl[127] br[127] wl[47] gnd reram_bitcell_7
Xbit_r48_c127 bl[127] br[127] wl[48] gnd reram_bitcell_7
Xbit_r49_c127 bl[127] br[127] wl[49] gnd reram_bitcell_7
Xbit_r50_c127 bl[127] br[127] wl[50] gnd reram_bitcell_7
Xbit_r51_c127 bl[127] br[127] wl[51] gnd reram_bitcell_7
Xbit_r52_c127 bl[127] br[127] wl[52] gnd reram_bitcell_7
Xbit_r53_c127 bl[127] br[127] wl[53] gnd reram_bitcell_7
Xbit_r54_c127 bl[127] br[127] wl[54] gnd reram_bitcell_7
Xbit_r55_c127 bl[127] br[127] wl[55] gnd reram_bitcell_7
Xbit_r56_c127 bl[127] br[127] wl[56] gnd reram_bitcell_7
Xbit_r57_c127 bl[127] br[127] wl[57] gnd reram_bitcell_7
Xbit_r58_c127 bl[127] br[127] wl[58] gnd reram_bitcell_7
Xbit_r59_c127 bl[127] br[127] wl[59] gnd reram_bitcell_7
Xbit_r60_c127 bl[127] br[127] wl[60] gnd reram_bitcell_7
Xbit_r61_c127 bl[127] br[127] wl[61] gnd reram_bitcell_7
Xbit_r62_c127 bl[127] br[127] wl[62] gnd reram_bitcell_7
Xbit_r63_c127 bl[127] br[127] wl[63] gnd reram_bitcell_7
.ENDS bitcell_array

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.88 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=7.2 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT tri_state_4 in_bar out en en_bar vdd gnd
Xnmos0 gnd en left_mid_n gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos1 left_mid_n in_bar out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos2 gnd en right_mid_n gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos3 right_mid_n in_bar out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xpmos0 vdd en_bar left_mid_p vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos1 left_mid_p in_bar out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos2 vdd en_bar right_mid_p vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos3 right_mid_p in_bar out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
.ENDS tri_state_4

.SUBCKT tri_gate_array in_bar[0] in_bar[1] in_bar[2] in_bar[3] in_bar[4] in_bar[5] in_bar[6] in_bar[7] in_bar[8] in_bar[9] in_bar[10] in_bar[11] in_bar[12] in_bar[13] in_bar[14] in_bar[15] in_bar[16] in_bar[17] in_bar[18] in_bar[19] in_bar[20] in_bar[21] in_bar[22] in_bar[23] in_bar[24] in_bar[25] in_bar[26] in_bar[27] in_bar[28] in_bar[29] in_bar[30] in_bar[31] in_bar[32] in_bar[33] in_bar[34] in_bar[35] in_bar[36] in_bar[37] in_bar[38] in_bar[39] in_bar[40] in_bar[41] in_bar[42] in_bar[43] in_bar[44] in_bar[45] in_bar[46] in_bar[47] in_bar[48] in_bar[49] in_bar[50] in_bar[51] in_bar[52] in_bar[53] in_bar[54] in_bar[55] in_bar[56] in_bar[57] in_bar[58] in_bar[59] in_bar[60] in_bar[61] in_bar[62] in_bar[63] out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] out[8] out[9] out[10] out[11] out[12] out[13] out[14] out[15] out[16] out[17] out[18] out[19] out[20] out[21] out[22] out[23] out[24] out[25] out[26] out[27] out[28] out[29] out[30] out[31] out[32] out[33] out[34] out[35] out[36] out[37] out[38] out[39] out[40] out[41] out[42] out[43] out[44] out[45] out[46] out[47] out[48] out[49] out[50] out[51] out[52] out[53] out[54] out[55] out[56] out[57] out[58] out[59] out[60] out[61] out[62] out[63] en en_bar vdd gnd
Xmod_0 in_bar[0] out[0] en en_bar vdd gnd tri_state_4
Xmod_1 in_bar[1] out[1] en en_bar vdd gnd tri_state_4
Xmod_2 in_bar[2] out[2] en en_bar vdd gnd tri_state_4
Xmod_3 in_bar[3] out[3] en en_bar vdd gnd tri_state_4
Xmod_4 in_bar[4] out[4] en en_bar vdd gnd tri_state_4
Xmod_5 in_bar[5] out[5] en en_bar vdd gnd tri_state_4
Xmod_6 in_bar[6] out[6] en en_bar vdd gnd tri_state_4
Xmod_7 in_bar[7] out[7] en en_bar vdd gnd tri_state_4
Xmod_8 in_bar[8] out[8] en en_bar vdd gnd tri_state_4
Xmod_9 in_bar[9] out[9] en en_bar vdd gnd tri_state_4
Xmod_10 in_bar[10] out[10] en en_bar vdd gnd tri_state_4
Xmod_11 in_bar[11] out[11] en en_bar vdd gnd tri_state_4
Xmod_12 in_bar[12] out[12] en en_bar vdd gnd tri_state_4
Xmod_13 in_bar[13] out[13] en en_bar vdd gnd tri_state_4
Xmod_14 in_bar[14] out[14] en en_bar vdd gnd tri_state_4
Xmod_15 in_bar[15] out[15] en en_bar vdd gnd tri_state_4
Xmod_16 in_bar[16] out[16] en en_bar vdd gnd tri_state_4
Xmod_17 in_bar[17] out[17] en en_bar vdd gnd tri_state_4
Xmod_18 in_bar[18] out[18] en en_bar vdd gnd tri_state_4
Xmod_19 in_bar[19] out[19] en en_bar vdd gnd tri_state_4
Xmod_20 in_bar[20] out[20] en en_bar vdd gnd tri_state_4
Xmod_21 in_bar[21] out[21] en en_bar vdd gnd tri_state_4
Xmod_22 in_bar[22] out[22] en en_bar vdd gnd tri_state_4
Xmod_23 in_bar[23] out[23] en en_bar vdd gnd tri_state_4
Xmod_24 in_bar[24] out[24] en en_bar vdd gnd tri_state_4
Xmod_25 in_bar[25] out[25] en en_bar vdd gnd tri_state_4
Xmod_26 in_bar[26] out[26] en en_bar vdd gnd tri_state_4
Xmod_27 in_bar[27] out[27] en en_bar vdd gnd tri_state_4
Xmod_28 in_bar[28] out[28] en en_bar vdd gnd tri_state_4
Xmod_29 in_bar[29] out[29] en en_bar vdd gnd tri_state_4
Xmod_30 in_bar[30] out[30] en en_bar vdd gnd tri_state_4
Xmod_31 in_bar[31] out[31] en en_bar vdd gnd tri_state_4
Xmod_32 in_bar[32] out[32] en en_bar vdd gnd tri_state_4
Xmod_33 in_bar[33] out[33] en en_bar vdd gnd tri_state_4
Xmod_34 in_bar[34] out[34] en en_bar vdd gnd tri_state_4
Xmod_35 in_bar[35] out[35] en en_bar vdd gnd tri_state_4
Xmod_36 in_bar[36] out[36] en en_bar vdd gnd tri_state_4
Xmod_37 in_bar[37] out[37] en en_bar vdd gnd tri_state_4
Xmod_38 in_bar[38] out[38] en en_bar vdd gnd tri_state_4
Xmod_39 in_bar[39] out[39] en en_bar vdd gnd tri_state_4
Xmod_40 in_bar[40] out[40] en en_bar vdd gnd tri_state_4
Xmod_41 in_bar[41] out[41] en en_bar vdd gnd tri_state_4
Xmod_42 in_bar[42] out[42] en en_bar vdd gnd tri_state_4
Xmod_43 in_bar[43] out[43] en en_bar vdd gnd tri_state_4
Xmod_44 in_bar[44] out[44] en en_bar vdd gnd tri_state_4
Xmod_45 in_bar[45] out[45] en en_bar vdd gnd tri_state_4
Xmod_46 in_bar[46] out[46] en en_bar vdd gnd tri_state_4
Xmod_47 in_bar[47] out[47] en en_bar vdd gnd tri_state_4
Xmod_48 in_bar[48] out[48] en en_bar vdd gnd tri_state_4
Xmod_49 in_bar[49] out[49] en en_bar vdd gnd tri_state_4
Xmod_50 in_bar[50] out[50] en en_bar vdd gnd tri_state_4
Xmod_51 in_bar[51] out[51] en en_bar vdd gnd tri_state_4
Xmod_52 in_bar[52] out[52] en en_bar vdd gnd tri_state_4
Xmod_53 in_bar[53] out[53] en en_bar vdd gnd tri_state_4
Xmod_54 in_bar[54] out[54] en en_bar vdd gnd tri_state_4
Xmod_55 in_bar[55] out[55] en en_bar vdd gnd tri_state_4
Xmod_56 in_bar[56] out[56] en en_bar vdd gnd tri_state_4
Xmod_57 in_bar[57] out[57] en en_bar vdd gnd tri_state_4
Xmod_58 in_bar[58] out[58] en en_bar vdd gnd tri_state_4
Xmod_59 in_bar[59] out[59] en en_bar vdd gnd tri_state_4
Xmod_60 in_bar[60] out[60] en en_bar vdd gnd tri_state_4
Xmod_61 in_bar[61] out[61] en en_bar vdd gnd tri_state_4
Xmod_62 in_bar[62] out[62] en en_bar vdd gnd tri_state_4
Xmod_63 in_bar[63] out[63] en en_bar vdd gnd tri_state_4
.ENDS tri_gate_array
.subckt re_ram_sense_amp bl br dout dout_bar en gnd sampleb vclamp vclampp vdd vref
xm1 vdata vclamp bl gnd sky130_fd_pr__nfet_01v8 l=0.15 w=1.44 nf=4
+ sa=0 sb=0 sd=0 mult=1 m=1
xm2 vdata vclampp net1 vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 net1 sampleb vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 net3 vdata net2 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 dout vref net2 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 net2 en gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=1.2 nf=2
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout net3 vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.2 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm8 net3 net3 vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.2 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm9 dout_bar dout gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=2
+   sa=0 sb=0 sd=0 mult=1 m=1
xm10 dout_bar dout vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.44 nf=2
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

.SUBCKT sense_amp_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] bl[32] bl[33] bl[34] bl[35] bl[36] bl[37] bl[38] bl[39] bl[40] bl[41] bl[42] bl[43] bl[44] bl[45] bl[46] bl[47] bl[48] bl[49] bl[50] bl[51] bl[52] bl[53] bl[54] bl[55] bl[56] bl[57] bl[58] bl[59] bl[60] bl[61] bl[62] bl[63] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] br[32] br[33] br[34] br[35] br[36] br[37] br[38] br[39] br[40] br[41] br[42] br[43] br[44] br[45] br[46] br[47] br[48] br[49] br[50] br[51] br[52] br[53] br[54] br[55] br[56] br[57] br[58] br[59] br[60] br[61] br[62] br[63] dout[0] dout[1] dout[2] dout[3] dout[4] dout[5] dout[6] dout[7] dout[8] dout[9] dout[10] dout[11] dout[12] dout[13] dout[14] dout[15] dout[16] dout[17] dout[18] dout[19] dout[20] dout[21] dout[22] dout[23] dout[24] dout[25] dout[26] dout[27] dout[28] dout[29] dout[30] dout[31] dout[32] dout[33] dout[34] dout[35] dout[36] dout[37] dout[38] dout[39] dout[40] dout[41] dout[42] dout[43] dout[44] dout[45] dout[46] dout[47] dout[48] dout[49] dout[50] dout[51] dout[52] dout[53] dout[54] dout[55] dout[56] dout[57] dout[58] dout[59] dout[60] dout[61] dout[62] dout[63] dout_bar[0] dout_bar[1] dout_bar[2] dout_bar[3] dout_bar[4] dout_bar[5] dout_bar[6] dout_bar[7] dout_bar[8] dout_bar[9] dout_bar[10] dout_bar[11] dout_bar[12] dout_bar[13] dout_bar[14] dout_bar[15] dout_bar[16] dout_bar[17] dout_bar[18] dout_bar[19] dout_bar[20] dout_bar[21] dout_bar[22] dout_bar[23] dout_bar[24] dout_bar[25] dout_bar[26] dout_bar[27] dout_bar[28] dout_bar[29] dout_bar[30] dout_bar[31] dout_bar[32] dout_bar[33] dout_bar[34] dout_bar[35] dout_bar[36] dout_bar[37] dout_bar[38] dout_bar[39] dout_bar[40] dout_bar[41] dout_bar[42] dout_bar[43] dout_bar[44] dout_bar[45] dout_bar[46] dout_bar[47] dout_bar[48] dout_bar[49] dout_bar[50] dout_bar[51] dout_bar[52] dout_bar[53] dout_bar[54] dout_bar[55] dout_bar[56] dout_bar[57] dout_bar[58] dout_bar[59] dout_bar[60] dout_bar[61] dout_bar[62] dout_bar[63] en gnd sampleb vclamp vclampp vdd vref
Xmod_0 bl[0] br[0] dout[0] dout_bar[0] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_1 bl[1] br[1] dout[1] dout_bar[1] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_2 bl[2] br[2] dout[2] dout_bar[2] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_3 bl[3] br[3] dout[3] dout_bar[3] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_4 bl[4] br[4] dout[4] dout_bar[4] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_5 bl[5] br[5] dout[5] dout_bar[5] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_6 bl[6] br[6] dout[6] dout_bar[6] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_7 bl[7] br[7] dout[7] dout_bar[7] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_8 bl[8] br[8] dout[8] dout_bar[8] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_9 bl[9] br[9] dout[9] dout_bar[9] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_10 bl[10] br[10] dout[10] dout_bar[10] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_11 bl[11] br[11] dout[11] dout_bar[11] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_12 bl[12] br[12] dout[12] dout_bar[12] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_13 bl[13] br[13] dout[13] dout_bar[13] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_14 bl[14] br[14] dout[14] dout_bar[14] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_15 bl[15] br[15] dout[15] dout_bar[15] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_16 bl[16] br[16] dout[16] dout_bar[16] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_17 bl[17] br[17] dout[17] dout_bar[17] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_18 bl[18] br[18] dout[18] dout_bar[18] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_19 bl[19] br[19] dout[19] dout_bar[19] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_20 bl[20] br[20] dout[20] dout_bar[20] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_21 bl[21] br[21] dout[21] dout_bar[21] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_22 bl[22] br[22] dout[22] dout_bar[22] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_23 bl[23] br[23] dout[23] dout_bar[23] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_24 bl[24] br[24] dout[24] dout_bar[24] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_25 bl[25] br[25] dout[25] dout_bar[25] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_26 bl[26] br[26] dout[26] dout_bar[26] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_27 bl[27] br[27] dout[27] dout_bar[27] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_28 bl[28] br[28] dout[28] dout_bar[28] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_29 bl[29] br[29] dout[29] dout_bar[29] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_30 bl[30] br[30] dout[30] dout_bar[30] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_31 bl[31] br[31] dout[31] dout_bar[31] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_32 bl[32] br[32] dout[32] dout_bar[32] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_33 bl[33] br[33] dout[33] dout_bar[33] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_34 bl[34] br[34] dout[34] dout_bar[34] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_35 bl[35] br[35] dout[35] dout_bar[35] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_36 bl[36] br[36] dout[36] dout_bar[36] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_37 bl[37] br[37] dout[37] dout_bar[37] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_38 bl[38] br[38] dout[38] dout_bar[38] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_39 bl[39] br[39] dout[39] dout_bar[39] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_40 bl[40] br[40] dout[40] dout_bar[40] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_41 bl[41] br[41] dout[41] dout_bar[41] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_42 bl[42] br[42] dout[42] dout_bar[42] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_43 bl[43] br[43] dout[43] dout_bar[43] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_44 bl[44] br[44] dout[44] dout_bar[44] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_45 bl[45] br[45] dout[45] dout_bar[45] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_46 bl[46] br[46] dout[46] dout_bar[46] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_47 bl[47] br[47] dout[47] dout_bar[47] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_48 bl[48] br[48] dout[48] dout_bar[48] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_49 bl[49] br[49] dout[49] dout_bar[49] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_50 bl[50] br[50] dout[50] dout_bar[50] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_51 bl[51] br[51] dout[51] dout_bar[51] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_52 bl[52] br[52] dout[52] dout_bar[52] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_53 bl[53] br[53] dout[53] dout_bar[53] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_54 bl[54] br[54] dout[54] dout_bar[54] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_55 bl[55] br[55] dout[55] dout_bar[55] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_56 bl[56] br[56] dout[56] dout_bar[56] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_57 bl[57] br[57] dout[57] dout_bar[57] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_58 bl[58] br[58] dout[58] dout_bar[58] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_59 bl[59] br[59] dout[59] dout_bar[59] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_60 bl[60] br[60] dout[60] dout_bar[60] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_61 bl[61] br[61] dout[61] dout_bar[61] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_62 bl[62] br[62] dout[62] dout_bar[62] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_63 bl[63] br[63] dout[63] dout_bar[63] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
.ENDS sense_amp_array

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=2 w=0.72 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=1.8 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=7.2 l=0.15 pd=14.700000000000001 ps=14.700000000000001 as=2.7 ad=2.7

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.88 l=0.15 pd=6.06 ps=6.06 as=1.08 ad=1.08

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.88 l=0.15 pd=6.06 ps=6.06 as=1.08 ad=1.08

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=7.2 l=0.15 pd=14.700000000000001 ps=14.700000000000001 as=2.7 ad=2.7

.SUBCKT tgate_col_mux_1_8_20 bl br bl_out br_out sel vdd gnd
Xinv_nmos sel_bar sel gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
Xinv_pmos sel_bar sel vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xbuf_nmos sel_buf sel_bar gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
Xbuf_pmos sel_buf sel_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xbl_nmos bl sel_buf bl_out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.88 l=0.15 pd=6.06 ps=6.06 as=1.08 ad=1.08
Xbr_nmos br sel_buf br_out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.88 l=0.15 pd=6.06 ps=6.06 as=1.08 ad=1.08
Xbl_pmos bl sel_bar bl_out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=7.2 l=0.15 pd=14.700000000000001 ps=14.700000000000001 as=2.7 ad=2.7
Xbr_pmos br sel_bar br_out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=7.2 l=0.15 pd=14.700000000000001 ps=14.700000000000001 as=2.7 ad=2.7
.ENDS tgate_col_mux_1_8_20

.SUBCKT columnmux_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] bl[64] br[64] bl[65] br[65] bl[66] br[66] bl[67] br[67] bl[68] br[68] bl[69] br[69] bl[70] br[70] bl[71] br[71] bl[72] br[72] bl[73] br[73] bl[74] br[74] bl[75] br[75] bl[76] br[76] bl[77] br[77] bl[78] br[78] bl[79] br[79] bl[80] br[80] bl[81] br[81] bl[82] br[82] bl[83] br[83] bl[84] br[84] bl[85] br[85] bl[86] br[86] bl[87] br[87] bl[88] br[88] bl[89] br[89] bl[90] br[90] bl[91] br[91] bl[92] br[92] bl[93] br[93] bl[94] br[94] bl[95] br[95] bl[96] br[96] bl[97] br[97] bl[98] br[98] bl[99] br[99] bl[100] br[100] bl[101] br[101] bl[102] br[102] bl[103] br[103] bl[104] br[104] bl[105] br[105] bl[106] br[106] bl[107] br[107] bl[108] br[108] bl[109] br[109] bl[110] br[110] bl[111] br[111] bl[112] br[112] bl[113] br[113] bl[114] br[114] bl[115] br[115] bl[116] br[116] bl[117] br[117] bl[118] br[118] bl[119] br[119] bl[120] br[120] bl[121] br[121] bl[122] br[122] bl[123] br[123] bl[124] br[124] bl[125] br[125] bl[126] br[126] bl[127] br[127] sel[0] sel[1] bl_out[0] br_out[0] bl_out[1] br_out[1] bl_out[2] br_out[2] bl_out[3] br_out[3] bl_out[4] br_out[4] bl_out[5] br_out[5] bl_out[6] br_out[6] bl_out[7] br_out[7] bl_out[8] br_out[8] bl_out[9] br_out[9] bl_out[10] br_out[10] bl_out[11] br_out[11] bl_out[12] br_out[12] bl_out[13] br_out[13] bl_out[14] br_out[14] bl_out[15] br_out[15] bl_out[16] br_out[16] bl_out[17] br_out[17] bl_out[18] br_out[18] bl_out[19] br_out[19] bl_out[20] br_out[20] bl_out[21] br_out[21] bl_out[22] br_out[22] bl_out[23] br_out[23] bl_out[24] br_out[24] bl_out[25] br_out[25] bl_out[26] br_out[26] bl_out[27] br_out[27] bl_out[28] br_out[28] bl_out[29] br_out[29] bl_out[30] br_out[30] bl_out[31] br_out[31] bl_out[32] br_out[32] bl_out[33] br_out[33] bl_out[34] br_out[34] bl_out[35] br_out[35] bl_out[36] br_out[36] bl_out[37] br_out[37] bl_out[38] br_out[38] bl_out[39] br_out[39] bl_out[40] br_out[40] bl_out[41] br_out[41] bl_out[42] br_out[42] bl_out[43] br_out[43] bl_out[44] br_out[44] bl_out[45] br_out[45] bl_out[46] br_out[46] bl_out[47] br_out[47] bl_out[48] br_out[48] bl_out[49] br_out[49] bl_out[50] br_out[50] bl_out[51] br_out[51] bl_out[52] br_out[52] bl_out[53] br_out[53] bl_out[54] br_out[54] bl_out[55] br_out[55] bl_out[56] br_out[56] bl_out[57] br_out[57] bl_out[58] br_out[58] bl_out[59] br_out[59] bl_out[60] br_out[60] bl_out[61] br_out[61] bl_out[62] br_out[62] bl_out[63] br_out[63] vdd gnd
Xmod_0 bl[0] br[0] bl_out[0] br_out[0] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_1 bl[1] br[1] bl_out[0] br_out[0] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_2 bl[2] br[2] bl_out[1] br_out[1] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_3 bl[3] br[3] bl_out[1] br_out[1] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_4 bl[4] br[4] bl_out[2] br_out[2] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_5 bl[5] br[5] bl_out[2] br_out[2] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_6 bl[6] br[6] bl_out[3] br_out[3] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_7 bl[7] br[7] bl_out[3] br_out[3] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_8 bl[8] br[8] bl_out[4] br_out[4] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_9 bl[9] br[9] bl_out[4] br_out[4] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_10 bl[10] br[10] bl_out[5] br_out[5] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_11 bl[11] br[11] bl_out[5] br_out[5] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_12 bl[12] br[12] bl_out[6] br_out[6] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_13 bl[13] br[13] bl_out[6] br_out[6] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_14 bl[14] br[14] bl_out[7] br_out[7] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_15 bl[15] br[15] bl_out[7] br_out[7] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_16 bl[16] br[16] bl_out[8] br_out[8] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_17 bl[17] br[17] bl_out[8] br_out[8] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_18 bl[18] br[18] bl_out[9] br_out[9] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_19 bl[19] br[19] bl_out[9] br_out[9] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_20 bl[20] br[20] bl_out[10] br_out[10] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_21 bl[21] br[21] bl_out[10] br_out[10] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_22 bl[22] br[22] bl_out[11] br_out[11] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_23 bl[23] br[23] bl_out[11] br_out[11] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_24 bl[24] br[24] bl_out[12] br_out[12] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_25 bl[25] br[25] bl_out[12] br_out[12] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_26 bl[26] br[26] bl_out[13] br_out[13] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_27 bl[27] br[27] bl_out[13] br_out[13] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_28 bl[28] br[28] bl_out[14] br_out[14] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_29 bl[29] br[29] bl_out[14] br_out[14] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_30 bl[30] br[30] bl_out[15] br_out[15] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_31 bl[31] br[31] bl_out[15] br_out[15] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_32 bl[32] br[32] bl_out[16] br_out[16] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_33 bl[33] br[33] bl_out[16] br_out[16] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_34 bl[34] br[34] bl_out[17] br_out[17] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_35 bl[35] br[35] bl_out[17] br_out[17] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_36 bl[36] br[36] bl_out[18] br_out[18] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_37 bl[37] br[37] bl_out[18] br_out[18] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_38 bl[38] br[38] bl_out[19] br_out[19] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_39 bl[39] br[39] bl_out[19] br_out[19] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_40 bl[40] br[40] bl_out[20] br_out[20] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_41 bl[41] br[41] bl_out[20] br_out[20] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_42 bl[42] br[42] bl_out[21] br_out[21] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_43 bl[43] br[43] bl_out[21] br_out[21] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_44 bl[44] br[44] bl_out[22] br_out[22] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_45 bl[45] br[45] bl_out[22] br_out[22] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_46 bl[46] br[46] bl_out[23] br_out[23] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_47 bl[47] br[47] bl_out[23] br_out[23] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_48 bl[48] br[48] bl_out[24] br_out[24] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_49 bl[49] br[49] bl_out[24] br_out[24] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_50 bl[50] br[50] bl_out[25] br_out[25] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_51 bl[51] br[51] bl_out[25] br_out[25] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_52 bl[52] br[52] bl_out[26] br_out[26] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_53 bl[53] br[53] bl_out[26] br_out[26] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_54 bl[54] br[54] bl_out[27] br_out[27] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_55 bl[55] br[55] bl_out[27] br_out[27] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_56 bl[56] br[56] bl_out[28] br_out[28] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_57 bl[57] br[57] bl_out[28] br_out[28] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_58 bl[58] br[58] bl_out[29] br_out[29] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_59 bl[59] br[59] bl_out[29] br_out[29] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_60 bl[60] br[60] bl_out[30] br_out[30] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_61 bl[61] br[61] bl_out[30] br_out[30] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_62 bl[62] br[62] bl_out[31] br_out[31] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_63 bl[63] br[63] bl_out[31] br_out[31] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_64 bl[64] br[64] bl_out[32] br_out[32] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_65 bl[65] br[65] bl_out[32] br_out[32] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_66 bl[66] br[66] bl_out[33] br_out[33] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_67 bl[67] br[67] bl_out[33] br_out[33] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_68 bl[68] br[68] bl_out[34] br_out[34] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_69 bl[69] br[69] bl_out[34] br_out[34] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_70 bl[70] br[70] bl_out[35] br_out[35] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_71 bl[71] br[71] bl_out[35] br_out[35] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_72 bl[72] br[72] bl_out[36] br_out[36] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_73 bl[73] br[73] bl_out[36] br_out[36] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_74 bl[74] br[74] bl_out[37] br_out[37] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_75 bl[75] br[75] bl_out[37] br_out[37] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_76 bl[76] br[76] bl_out[38] br_out[38] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_77 bl[77] br[77] bl_out[38] br_out[38] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_78 bl[78] br[78] bl_out[39] br_out[39] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_79 bl[79] br[79] bl_out[39] br_out[39] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_80 bl[80] br[80] bl_out[40] br_out[40] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_81 bl[81] br[81] bl_out[40] br_out[40] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_82 bl[82] br[82] bl_out[41] br_out[41] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_83 bl[83] br[83] bl_out[41] br_out[41] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_84 bl[84] br[84] bl_out[42] br_out[42] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_85 bl[85] br[85] bl_out[42] br_out[42] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_86 bl[86] br[86] bl_out[43] br_out[43] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_87 bl[87] br[87] bl_out[43] br_out[43] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_88 bl[88] br[88] bl_out[44] br_out[44] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_89 bl[89] br[89] bl_out[44] br_out[44] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_90 bl[90] br[90] bl_out[45] br_out[45] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_91 bl[91] br[91] bl_out[45] br_out[45] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_92 bl[92] br[92] bl_out[46] br_out[46] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_93 bl[93] br[93] bl_out[46] br_out[46] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_94 bl[94] br[94] bl_out[47] br_out[47] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_95 bl[95] br[95] bl_out[47] br_out[47] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_96 bl[96] br[96] bl_out[48] br_out[48] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_97 bl[97] br[97] bl_out[48] br_out[48] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_98 bl[98] br[98] bl_out[49] br_out[49] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_99 bl[99] br[99] bl_out[49] br_out[49] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_100 bl[100] br[100] bl_out[50] br_out[50] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_101 bl[101] br[101] bl_out[50] br_out[50] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_102 bl[102] br[102] bl_out[51] br_out[51] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_103 bl[103] br[103] bl_out[51] br_out[51] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_104 bl[104] br[104] bl_out[52] br_out[52] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_105 bl[105] br[105] bl_out[52] br_out[52] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_106 bl[106] br[106] bl_out[53] br_out[53] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_107 bl[107] br[107] bl_out[53] br_out[53] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_108 bl[108] br[108] bl_out[54] br_out[54] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_109 bl[109] br[109] bl_out[54] br_out[54] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_110 bl[110] br[110] bl_out[55] br_out[55] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_111 bl[111] br[111] bl_out[55] br_out[55] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_112 bl[112] br[112] bl_out[56] br_out[56] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_113 bl[113] br[113] bl_out[56] br_out[56] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_114 bl[114] br[114] bl_out[57] br_out[57] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_115 bl[115] br[115] bl_out[57] br_out[57] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_116 bl[116] br[116] bl_out[58] br_out[58] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_117 bl[117] br[117] bl_out[58] br_out[58] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_118 bl[118] br[118] bl_out[59] br_out[59] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_119 bl[119] br[119] bl_out[59] br_out[59] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_120 bl[120] br[120] bl_out[60] br_out[60] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_121 bl[121] br[121] bl_out[60] br_out[60] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_122 bl[122] br[122] bl_out[61] br_out[61] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_123 bl[123] br[123] bl_out[61] br_out[61] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_124 bl[124] br[124] bl_out[62] br_out[62] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_125 bl[125] br[125] bl_out[62] br_out[62] sel[1] vdd gnd tgate_col_mux_1_8_20
Xmod_126 bl[126] br[126] bl_out[63] br_out[63] sel[0] vdd gnd tgate_col_mux_1_8_20
Xmod_127 bl[127] br[127] bl_out[63] br_out[63] sel[1] vdd gnd tgate_col_mux_1_8_20
.ENDS columnmux_array

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375

.SUBCKT pinv_1_no_p_no_n_align_same_line A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1_no_p_no_n_align_same_line

.SUBCKT pnand2_1_no_p_no_n_align_same_line A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pnand2_1_no_p_no_n_align_same_line

.SUBCKT pnand3_1_no_p_no_n_align_same_line A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pnand3_1_no_p_no_n_align_same_line
.subckt ms_flop_horz_pitch din dout dout_bar clk vdd gnd
xm1 clk_buf clk_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 clk_buf clk_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 clk_bar clk gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm3 clk_bar clk vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 din clk_buf vdd gnd lout lout_bar clk_bar dlatch2
x2 lout_bar clk_bar vdd gnd dout_bar dout clk_buf dlatch2
.ends
.subckt dlatch2  din clk vdd gnd dout dout_bar clk_bar
xm1 dout dout_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 dout_bar int gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 int clk dout gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 int clk_bar dout vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 int clk_bar din gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 int clk din vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout_bar int vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 dout dout_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=4.28 l=0.15 pd=2.44 ps=2.44 as=0.40125 ad=0.40125

.SUBCKT pinv_4__76_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=4.28 l=0.15 pd=2.44 ps=2.44 as=0.40125 ad=0.40125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=1.72 l=0.15 pd=1.16 ps=1.16 as=0.16125 ad=0.16125
.ENDS pinv_4__76_h_3__2

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.8250000000000001 l=0.15 pd=1.9500000000000002 ps=1.9500000000000002 as=0.309375 ad=0.309375

.SUBCKT pnand2_1__02_no_p_no_n_h_3__2 A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.8250000000000001 l=0.15 pd=1.9500000000000002 ps=1.9500000000000002 as=0.309375 ad=0.309375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.8250000000000001 l=0.15 pd=1.9500000000000002 ps=1.9500000000000002 as=0.309375 ad=0.309375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.66 l=0.15 pd=1.62 ps=1.62 as=0.2475 ad=0.2475
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.66 l=0.15 pd=1.62 ps=1.62 as=0.2475 ad=0.2475
.ENDS pnand2_1__02_no_p_no_n_h_3__2

.SUBCKT buffer_stage_4__76_no_out_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_4__76_h_3__2
.ENDS buffer_stage_4__76_no_out_h_3__2

.SUBCKT pinv_4__76_h_3__2_fake_c A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=4.28 l=0.15 pd=2.44 ps=2.44 as=0.40125 ad=0.40125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=1.72 l=0.15 pd=1.16 ps=1.16 as=0.16125 ad=0.16125
.ENDS pinv_4__76_h_3__2_fake_c

.SUBCKT buffer_stage_4__76_no_out_h_3__2_fake_c in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_4__76_h_3__2_fake_c
.ENDS buffer_stage_4__76_no_out_h_3__2_fake_c

.SUBCKT pre2x4_no_top_flops flop_in[0] flop_in[1] out[0] out[1] out[2] out[3] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_4__76_no_out_h_3__2_fake_c
Xpre2x4_nand_0 inbar[0] inbar[1] Z[0] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_1 in[0] inbar[1] Z[1] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_2 inbar[0] in[1] Z[2] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_3 in[0] in[1] Z[3] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
.ENDS pre2x4_no_top_flops

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025

.SUBCKT pnand3_1_no_p_no_n_h_3__2 A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
.ENDS pnand3_1_no_p_no_n_h_3__2

.SUBCKT pre3x8_no_top_flops flop_in[0] flop_in[1] flop_in[2] out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xflop_2 flop_in[2] in[2] inbar[2] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_4 Z[4] out[4] Z[4] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_5 Z[5] out[5] Z[5] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_6 Z[6] out[6] Z[6] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_7 Z[7] out[7] Z[7] vdd gnd buffer_stage_4__76_no_out_h_3__2_fake_c
Xpre3x8_nand_0 inbar[0] inbar[1] inbar[2] Z[0] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_1 in[0] inbar[1] inbar[2] Z[1] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_2 inbar[0] in[1] inbar[2] Z[2] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_3 in[0] in[1] inbar[2] Z[3] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_4 inbar[0] inbar[1] in[2] Z[4] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_5 in[0] inbar[1] in[2] Z[5] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_6 inbar[0] in[1] in[2] Z[6] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_7 in[0] in[1] in[2] Z[7] vdd gnd pnand3_1_no_p_no_n_h_3__2
.ENDS pre3x8_no_top_flops

.SUBCKT pre2x4_flops flop_in[0] flop_in[1] out[0] out[1] out[2] out[3] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_4__76_no_out_h_3__2
Xpre2x4_nand_0 inbar[0] inbar[1] Z[0] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_1 in[0] inbar[1] Z[1] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_2 inbar[0] in[1] Z[2] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_3 in[0] in[1] Z[3] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
.ENDS pre2x4_flops

.SUBCKT hierarchical_decoder_64rows A[0] A[1] A[2] A[3] A[4] A[5] decode[0] decode[1] decode[2] decode[3] decode[4] decode[5] decode[6] decode[7] decode[8] decode[9] decode[10] decode[11] decode[12] decode[13] decode[14] decode[15] decode[16] decode[17] decode[18] decode[19] decode[20] decode[21] decode[22] decode[23] decode[24] decode[25] decode[26] decode[27] decode[28] decode[29] decode[30] decode[31] decode[32] decode[33] decode[34] decode[35] decode[36] decode[37] decode[38] decode[39] decode[40] decode[41] decode[42] decode[43] decode[44] decode[45] decode[46] decode[47] decode[48] decode[49] decode[50] decode[51] decode[52] decode[53] decode[54] decode[55] decode[56] decode[57] decode[58] decode[59] decode[60] decode[61] decode[62] decode[63] clk vdd gnd
Xpre_0 A[0] A[1] out[0] out[1] out[2] out[3] clk vdd gnd pre2x4_no_top_flops
Xpre_1 A[2] A[3] out[4] out[5] out[6] out[7] clk vdd gnd pre2x4_no_top_flops
Xpre_2 A[4] A[5] out[8] out[9] out[10] out[11] clk vdd gnd pre2x4_flops
XDEC_NAND[0] out[0] out[4] out[8] Z[0] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[1] out[1] out[4] out[8] Z[1] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[2] out[2] out[4] out[8] Z[2] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[3] out[3] out[4] out[8] Z[3] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[4] out[0] out[5] out[8] Z[4] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[5] out[1] out[5] out[8] Z[5] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[6] out[2] out[5] out[8] Z[6] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[7] out[3] out[5] out[8] Z[7] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[8] out[0] out[6] out[8] Z[8] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[9] out[1] out[6] out[8] Z[9] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[10] out[2] out[6] out[8] Z[10] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[11] out[3] out[6] out[8] Z[11] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[12] out[0] out[7] out[8] Z[12] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[13] out[1] out[7] out[8] Z[13] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[14] out[2] out[7] out[8] Z[14] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[15] out[3] out[7] out[8] Z[15] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[16] out[0] out[4] out[9] Z[16] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[17] out[1] out[4] out[9] Z[17] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[18] out[2] out[4] out[9] Z[18] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[19] out[3] out[4] out[9] Z[19] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[20] out[0] out[5] out[9] Z[20] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[21] out[1] out[5] out[9] Z[21] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[22] out[2] out[5] out[9] Z[22] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[23] out[3] out[5] out[9] Z[23] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[24] out[0] out[6] out[9] Z[24] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[25] out[1] out[6] out[9] Z[25] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[26] out[2] out[6] out[9] Z[26] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[27] out[3] out[6] out[9] Z[27] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[28] out[0] out[7] out[9] Z[28] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[29] out[1] out[7] out[9] Z[29] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[30] out[2] out[7] out[9] Z[30] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[31] out[3] out[7] out[9] Z[31] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[32] out[0] out[4] out[10] Z[32] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[33] out[1] out[4] out[10] Z[33] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[34] out[2] out[4] out[10] Z[34] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[35] out[3] out[4] out[10] Z[35] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[36] out[0] out[5] out[10] Z[36] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[37] out[1] out[5] out[10] Z[37] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[38] out[2] out[5] out[10] Z[38] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[39] out[3] out[5] out[10] Z[39] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[40] out[0] out[6] out[10] Z[40] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[41] out[1] out[6] out[10] Z[41] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[42] out[2] out[6] out[10] Z[42] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[43] out[3] out[6] out[10] Z[43] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[44] out[0] out[7] out[10] Z[44] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[45] out[1] out[7] out[10] Z[45] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[46] out[2] out[7] out[10] Z[46] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[47] out[3] out[7] out[10] Z[47] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[48] out[0] out[4] out[11] Z[48] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[49] out[1] out[4] out[11] Z[49] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[50] out[2] out[4] out[11] Z[50] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[51] out[3] out[4] out[11] Z[51] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[52] out[0] out[5] out[11] Z[52] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[53] out[1] out[5] out[11] Z[53] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[54] out[2] out[5] out[11] Z[54] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[55] out[3] out[5] out[11] Z[55] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[56] out[0] out[6] out[11] Z[56] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[57] out[1] out[6] out[11] Z[57] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[58] out[2] out[6] out[11] Z[58] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[59] out[3] out[6] out[11] Z[59] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[60] out[0] out[7] out[11] Z[60] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[61] out[1] out[7] out[11] Z[61] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[62] out[2] out[7] out[11] Z[62] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_NAND[63] out[3] out[7] out[11] Z[63] vdd gnd pnand3_1_no_p_no_n_align_same_line
XDEC_INV_[0] Z[0] decode[0] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[1] Z[1] decode[1] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[2] Z[2] decode[2] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[3] Z[3] decode[3] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[4] Z[4] decode[4] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[5] Z[5] decode[5] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[6] Z[6] decode[6] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[7] Z[7] decode[7] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[8] Z[8] decode[8] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[9] Z[9] decode[9] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[10] Z[10] decode[10] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[11] Z[11] decode[11] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[12] Z[12] decode[12] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[13] Z[13] decode[13] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[14] Z[14] decode[14] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[15] Z[15] decode[15] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[16] Z[16] decode[16] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[17] Z[17] decode[17] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[18] Z[18] decode[18] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[19] Z[19] decode[19] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[20] Z[20] decode[20] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[21] Z[21] decode[21] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[22] Z[22] decode[22] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[23] Z[23] decode[23] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[24] Z[24] decode[24] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[25] Z[25] decode[25] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[26] Z[26] decode[26] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[27] Z[27] decode[27] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[28] Z[28] decode[28] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[29] Z[29] decode[29] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[30] Z[30] decode[30] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[31] Z[31] decode[31] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[32] Z[32] decode[32] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[33] Z[33] decode[33] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[34] Z[34] decode[34] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[35] Z[35] decode[35] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[36] Z[36] decode[36] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[37] Z[37] decode[37] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[38] Z[38] decode[38] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[39] Z[39] decode[39] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[40] Z[40] decode[40] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[41] Z[41] decode[41] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[42] Z[42] decode[42] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[43] Z[43] decode[43] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[44] Z[44] decode[44] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[45] Z[45] decode[45] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[46] Z[46] decode[46] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[47] Z[47] decode[47] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[48] Z[48] decode[48] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[49] Z[49] decode[49] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[50] Z[50] decode[50] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[51] Z[51] decode[51] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[52] Z[52] decode[52] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[53] Z[53] decode[53] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[54] Z[54] decode[54] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[55] Z[55] decode[55] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[56] Z[56] decode[56] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[57] Z[57] decode[57] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[58] Z[58] decode[58] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[59] Z[59] decode[59] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[60] Z[60] decode[60] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[61] Z[61] decode[61] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[62] Z[62] decode[62] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[63] Z[63] decode[63] vdd gnd pinv_1_no_p_no_n_align_same_line
.ENDS hierarchical_decoder_64rows

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=4.66 l=0.15 pd=4.96 ps=4.96 as=0.87375 ad=0.87375

.SUBCKT pinv_5__17_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=4.66 l=0.15 pd=4.96 ps=4.96 as=0.87375 ad=0.87375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.86 l=0.15 pd=2.16 ps=2.16 as=0.34875 ad=0.34875
.ENDS pinv_5__17_no_p_no_n_align

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=6 w=15.51 l=0.15 pd=5.47 ps=5.47 as=0.969375 ad=0.969375

.SUBCKT pinv_17__2_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=6 w=15.51 l=0.15 pd=5.47 ps=5.47 as=0.969375 ad=0.969375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=6 w=6.209999999999999 l=0.15 pd=2.3699999999999997 ps=2.3699999999999997 as=0.38812499999999994 ad=0.38812499999999994
.ENDS pinv_17__2_no_p_no_n_align

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=17.99 l=0.15 pd=5.4399999999999995 ps=5.4399999999999995 as=0.9637499999999999 ad=0.9637499999999999

.SUBCKT pinv_20_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=17.99 l=0.15 pd=5.4399999999999995 ps=5.4399999999999995 as=0.9637499999999999 ad=0.9637499999999999
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=7.21 l=0.15 pd=2.36 ps=2.36 as=0.38625 ad=0.38625
.ENDS pinv_20_no_p_no_n_align

.SUBCKT buffer_stage_5__17_17__2_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_5__17_no_p_no_n_align
Xinv1 out_1 out vdd gnd pinv_17__2_no_p_no_n_align
Xinv2 out out_inv vdd gnd pinv_20_no_p_no_n_align
.ENDS buffer_stage_5__17_17__2_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align

.SUBCKT logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnand2_1_no_p_no_n_align_same_line
Xbuffer logic_out out out_inv vdd gnd buffer_stage_5__17_17__2_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align
.ENDS logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align

.SUBCKT wordline_driver_array in[0] in[1] in[2] in[3] in[4] in[5] in[6] in[7] in[8] in[9] in[10] in[11] in[12] in[13] in[14] in[15] in[16] in[17] in[18] in[19] in[20] in[21] in[22] in[23] in[24] in[25] in[26] in[27] in[28] in[29] in[30] in[31] in[32] in[33] in[34] in[35] in[36] in[37] in[38] in[39] in[40] in[41] in[42] in[43] in[44] in[45] in[46] in[47] in[48] in[49] in[50] in[51] in[52] in[53] in[54] in[55] in[56] in[57] in[58] in[59] in[60] in[61] in[62] in[63] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] wl[32] wl[33] wl[34] wl[35] wl[36] wl[37] wl[38] wl[39] wl[40] wl[41] wl[42] wl[43] wl[44] wl[45] wl[46] wl[47] wl[48] wl[49] wl[50] wl[51] wl[52] wl[53] wl[54] wl[55] wl[56] wl[57] wl[58] wl[59] wl[60] wl[61] wl[62] wl[63] en vdd gnd
Xdriver0 en in[0] wl_bar[0] wl[0] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver1 en in[1] wl_bar[1] wl[1] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver2 en in[2] wl_bar[2] wl[2] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver3 en in[3] wl_bar[3] wl[3] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver4 en in[4] wl_bar[4] wl[4] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver5 en in[5] wl_bar[5] wl[5] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver6 en in[6] wl_bar[6] wl[6] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver7 en in[7] wl_bar[7] wl[7] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver8 en in[8] wl_bar[8] wl[8] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver9 en in[9] wl_bar[9] wl[9] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver10 en in[10] wl_bar[10] wl[10] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver11 en in[11] wl_bar[11] wl[11] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver12 en in[12] wl_bar[12] wl[12] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver13 en in[13] wl_bar[13] wl[13] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver14 en in[14] wl_bar[14] wl[14] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver15 en in[15] wl_bar[15] wl[15] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver16 en in[16] wl_bar[16] wl[16] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver17 en in[17] wl_bar[17] wl[17] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver18 en in[18] wl_bar[18] wl[18] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver19 en in[19] wl_bar[19] wl[19] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver20 en in[20] wl_bar[20] wl[20] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver21 en in[21] wl_bar[21] wl[21] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver22 en in[22] wl_bar[22] wl[22] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver23 en in[23] wl_bar[23] wl[23] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver24 en in[24] wl_bar[24] wl[24] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver25 en in[25] wl_bar[25] wl[25] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver26 en in[26] wl_bar[26] wl[26] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver27 en in[27] wl_bar[27] wl[27] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver28 en in[28] wl_bar[28] wl[28] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver29 en in[29] wl_bar[29] wl[29] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver30 en in[30] wl_bar[30] wl[30] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver31 en in[31] wl_bar[31] wl[31] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver32 en in[32] wl_bar[32] wl[32] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver33 en in[33] wl_bar[33] wl[33] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver34 en in[34] wl_bar[34] wl[34] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver35 en in[35] wl_bar[35] wl[35] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver36 en in[36] wl_bar[36] wl[36] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver37 en in[37] wl_bar[37] wl[37] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver38 en in[38] wl_bar[38] wl[38] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver39 en in[39] wl_bar[39] wl[39] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver40 en in[40] wl_bar[40] wl[40] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver41 en in[41] wl_bar[41] wl[41] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver42 en in[42] wl_bar[42] wl[42] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver43 en in[43] wl_bar[43] wl[43] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver44 en in[44] wl_bar[44] wl[44] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver45 en in[45] wl_bar[45] wl[45] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver46 en in[46] wl_bar[46] wl[46] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver47 en in[47] wl_bar[47] wl[47] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver48 en in[48] wl_bar[48] wl[48] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver49 en in[49] wl_bar[49] wl[49] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver50 en in[50] wl_bar[50] wl[50] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver51 en in[51] wl_bar[51] wl[51] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver52 en in[52] wl_bar[52] wl[52] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver53 en in[53] wl_bar[53] wl[53] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver54 en in[54] wl_bar[54] wl[54] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver55 en in[55] wl_bar[55] wl[55] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver56 en in[56] wl_bar[56] wl[56] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver57 en in[57] wl_bar[57] wl[57] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver58 en in[58] wl_bar[58] wl[58] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver59 en in[59] wl_bar[59] wl[59] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver60 en in[60] wl_bar[60] wl[60] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver61 en in[61] wl_bar[61] wl[61] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver62 en in[62] wl_bar[62] wl[62] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver63 en in[63] wl_bar[63] wl[63] vdd gnd logic_buffer_pnand2_5_17_17_2_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
.ENDS wordline_driver_array

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT discharge_10 bl br bl_reset br_reset gnd
Xbl_inst bl bl_reset gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xbr_inst br br_reset gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
.ENDS discharge_10

.SUBCKT precharge_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] bl[32] bl[33] bl[34] bl[35] bl[36] bl[37] bl[38] bl[39] bl[40] bl[41] bl[42] bl[43] bl[44] bl[45] bl[46] bl[47] bl[48] bl[49] bl[50] bl[51] bl[52] bl[53] bl[54] bl[55] bl[56] bl[57] bl[58] bl[59] bl[60] bl[61] bl[62] bl[63] bl[64] bl[65] bl[66] bl[67] bl[68] bl[69] bl[70] bl[71] bl[72] bl[73] bl[74] bl[75] bl[76] bl[77] bl[78] bl[79] bl[80] bl[81] bl[82] bl[83] bl[84] bl[85] bl[86] bl[87] bl[88] bl[89] bl[90] bl[91] bl[92] bl[93] bl[94] bl[95] bl[96] bl[97] bl[98] bl[99] bl[100] bl[101] bl[102] bl[103] bl[104] bl[105] bl[106] bl[107] bl[108] bl[109] bl[110] bl[111] bl[112] bl[113] bl[114] bl[115] bl[116] bl[117] bl[118] bl[119] bl[120] bl[121] bl[122] bl[123] bl[124] bl[125] bl[126] bl[127] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] br[32] br[33] br[34] br[35] br[36] br[37] br[38] br[39] br[40] br[41] br[42] br[43] br[44] br[45] br[46] br[47] br[48] br[49] br[50] br[51] br[52] br[53] br[54] br[55] br[56] br[57] br[58] br[59] br[60] br[61] br[62] br[63] br[64] br[65] br[66] br[67] br[68] br[69] br[70] br[71] br[72] br[73] br[74] br[75] br[76] br[77] br[78] br[79] br[80] br[81] br[82] br[83] br[84] br[85] br[86] br[87] br[88] br[89] br[90] br[91] br[92] br[93] br[94] br[95] br[96] br[97] br[98] br[99] br[100] br[101] br[102] br[103] br[104] br[105] br[106] br[107] br[108] br[109] br[110] br[111] br[112] br[113] br[114] br[115] br[116] br[117] br[118] br[119] br[120] br[121] br[122] br[123] br[124] br[125] br[126] br[127] bl_reset br_reset gnd
Xmod_0 bl[0] br[0] bl_reset br_reset gnd discharge_10
Xmod_1 bl[1] br[1] bl_reset br_reset gnd discharge_10
Xmod_2 bl[2] br[2] bl_reset br_reset gnd discharge_10
Xmod_3 bl[3] br[3] bl_reset br_reset gnd discharge_10
Xmod_4 bl[4] br[4] bl_reset br_reset gnd discharge_10
Xmod_5 bl[5] br[5] bl_reset br_reset gnd discharge_10
Xmod_6 bl[6] br[6] bl_reset br_reset gnd discharge_10
Xmod_7 bl[7] br[7] bl_reset br_reset gnd discharge_10
Xmod_8 bl[8] br[8] bl_reset br_reset gnd discharge_10
Xmod_9 bl[9] br[9] bl_reset br_reset gnd discharge_10
Xmod_10 bl[10] br[10] bl_reset br_reset gnd discharge_10
Xmod_11 bl[11] br[11] bl_reset br_reset gnd discharge_10
Xmod_12 bl[12] br[12] bl_reset br_reset gnd discharge_10
Xmod_13 bl[13] br[13] bl_reset br_reset gnd discharge_10
Xmod_14 bl[14] br[14] bl_reset br_reset gnd discharge_10
Xmod_15 bl[15] br[15] bl_reset br_reset gnd discharge_10
Xmod_16 bl[16] br[16] bl_reset br_reset gnd discharge_10
Xmod_17 bl[17] br[17] bl_reset br_reset gnd discharge_10
Xmod_18 bl[18] br[18] bl_reset br_reset gnd discharge_10
Xmod_19 bl[19] br[19] bl_reset br_reset gnd discharge_10
Xmod_20 bl[20] br[20] bl_reset br_reset gnd discharge_10
Xmod_21 bl[21] br[21] bl_reset br_reset gnd discharge_10
Xmod_22 bl[22] br[22] bl_reset br_reset gnd discharge_10
Xmod_23 bl[23] br[23] bl_reset br_reset gnd discharge_10
Xmod_24 bl[24] br[24] bl_reset br_reset gnd discharge_10
Xmod_25 bl[25] br[25] bl_reset br_reset gnd discharge_10
Xmod_26 bl[26] br[26] bl_reset br_reset gnd discharge_10
Xmod_27 bl[27] br[27] bl_reset br_reset gnd discharge_10
Xmod_28 bl[28] br[28] bl_reset br_reset gnd discharge_10
Xmod_29 bl[29] br[29] bl_reset br_reset gnd discharge_10
Xmod_30 bl[30] br[30] bl_reset br_reset gnd discharge_10
Xmod_31 bl[31] br[31] bl_reset br_reset gnd discharge_10
Xmod_32 bl[32] br[32] bl_reset br_reset gnd discharge_10
Xmod_33 bl[33] br[33] bl_reset br_reset gnd discharge_10
Xmod_34 bl[34] br[34] bl_reset br_reset gnd discharge_10
Xmod_35 bl[35] br[35] bl_reset br_reset gnd discharge_10
Xmod_36 bl[36] br[36] bl_reset br_reset gnd discharge_10
Xmod_37 bl[37] br[37] bl_reset br_reset gnd discharge_10
Xmod_38 bl[38] br[38] bl_reset br_reset gnd discharge_10
Xmod_39 bl[39] br[39] bl_reset br_reset gnd discharge_10
Xmod_40 bl[40] br[40] bl_reset br_reset gnd discharge_10
Xmod_41 bl[41] br[41] bl_reset br_reset gnd discharge_10
Xmod_42 bl[42] br[42] bl_reset br_reset gnd discharge_10
Xmod_43 bl[43] br[43] bl_reset br_reset gnd discharge_10
Xmod_44 bl[44] br[44] bl_reset br_reset gnd discharge_10
Xmod_45 bl[45] br[45] bl_reset br_reset gnd discharge_10
Xmod_46 bl[46] br[46] bl_reset br_reset gnd discharge_10
Xmod_47 bl[47] br[47] bl_reset br_reset gnd discharge_10
Xmod_48 bl[48] br[48] bl_reset br_reset gnd discharge_10
Xmod_49 bl[49] br[49] bl_reset br_reset gnd discharge_10
Xmod_50 bl[50] br[50] bl_reset br_reset gnd discharge_10
Xmod_51 bl[51] br[51] bl_reset br_reset gnd discharge_10
Xmod_52 bl[52] br[52] bl_reset br_reset gnd discharge_10
Xmod_53 bl[53] br[53] bl_reset br_reset gnd discharge_10
Xmod_54 bl[54] br[54] bl_reset br_reset gnd discharge_10
Xmod_55 bl[55] br[55] bl_reset br_reset gnd discharge_10
Xmod_56 bl[56] br[56] bl_reset br_reset gnd discharge_10
Xmod_57 bl[57] br[57] bl_reset br_reset gnd discharge_10
Xmod_58 bl[58] br[58] bl_reset br_reset gnd discharge_10
Xmod_59 bl[59] br[59] bl_reset br_reset gnd discharge_10
Xmod_60 bl[60] br[60] bl_reset br_reset gnd discharge_10
Xmod_61 bl[61] br[61] bl_reset br_reset gnd discharge_10
Xmod_62 bl[62] br[62] bl_reset br_reset gnd discharge_10
Xmod_63 bl[63] br[63] bl_reset br_reset gnd discharge_10
Xmod_64 bl[64] br[64] bl_reset br_reset gnd discharge_10
Xmod_65 bl[65] br[65] bl_reset br_reset gnd discharge_10
Xmod_66 bl[66] br[66] bl_reset br_reset gnd discharge_10
Xmod_67 bl[67] br[67] bl_reset br_reset gnd discharge_10
Xmod_68 bl[68] br[68] bl_reset br_reset gnd discharge_10
Xmod_69 bl[69] br[69] bl_reset br_reset gnd discharge_10
Xmod_70 bl[70] br[70] bl_reset br_reset gnd discharge_10
Xmod_71 bl[71] br[71] bl_reset br_reset gnd discharge_10
Xmod_72 bl[72] br[72] bl_reset br_reset gnd discharge_10
Xmod_73 bl[73] br[73] bl_reset br_reset gnd discharge_10
Xmod_74 bl[74] br[74] bl_reset br_reset gnd discharge_10
Xmod_75 bl[75] br[75] bl_reset br_reset gnd discharge_10
Xmod_76 bl[76] br[76] bl_reset br_reset gnd discharge_10
Xmod_77 bl[77] br[77] bl_reset br_reset gnd discharge_10
Xmod_78 bl[78] br[78] bl_reset br_reset gnd discharge_10
Xmod_79 bl[79] br[79] bl_reset br_reset gnd discharge_10
Xmod_80 bl[80] br[80] bl_reset br_reset gnd discharge_10
Xmod_81 bl[81] br[81] bl_reset br_reset gnd discharge_10
Xmod_82 bl[82] br[82] bl_reset br_reset gnd discharge_10
Xmod_83 bl[83] br[83] bl_reset br_reset gnd discharge_10
Xmod_84 bl[84] br[84] bl_reset br_reset gnd discharge_10
Xmod_85 bl[85] br[85] bl_reset br_reset gnd discharge_10
Xmod_86 bl[86] br[86] bl_reset br_reset gnd discharge_10
Xmod_87 bl[87] br[87] bl_reset br_reset gnd discharge_10
Xmod_88 bl[88] br[88] bl_reset br_reset gnd discharge_10
Xmod_89 bl[89] br[89] bl_reset br_reset gnd discharge_10
Xmod_90 bl[90] br[90] bl_reset br_reset gnd discharge_10
Xmod_91 bl[91] br[91] bl_reset br_reset gnd discharge_10
Xmod_92 bl[92] br[92] bl_reset br_reset gnd discharge_10
Xmod_93 bl[93] br[93] bl_reset br_reset gnd discharge_10
Xmod_94 bl[94] br[94] bl_reset br_reset gnd discharge_10
Xmod_95 bl[95] br[95] bl_reset br_reset gnd discharge_10
Xmod_96 bl[96] br[96] bl_reset br_reset gnd discharge_10
Xmod_97 bl[97] br[97] bl_reset br_reset gnd discharge_10
Xmod_98 bl[98] br[98] bl_reset br_reset gnd discharge_10
Xmod_99 bl[99] br[99] bl_reset br_reset gnd discharge_10
Xmod_100 bl[100] br[100] bl_reset br_reset gnd discharge_10
Xmod_101 bl[101] br[101] bl_reset br_reset gnd discharge_10
Xmod_102 bl[102] br[102] bl_reset br_reset gnd discharge_10
Xmod_103 bl[103] br[103] bl_reset br_reset gnd discharge_10
Xmod_104 bl[104] br[104] bl_reset br_reset gnd discharge_10
Xmod_105 bl[105] br[105] bl_reset br_reset gnd discharge_10
Xmod_106 bl[106] br[106] bl_reset br_reset gnd discharge_10
Xmod_107 bl[107] br[107] bl_reset br_reset gnd discharge_10
Xmod_108 bl[108] br[108] bl_reset br_reset gnd discharge_10
Xmod_109 bl[109] br[109] bl_reset br_reset gnd discharge_10
Xmod_110 bl[110] br[110] bl_reset br_reset gnd discharge_10
Xmod_111 bl[111] br[111] bl_reset br_reset gnd discharge_10
Xmod_112 bl[112] br[112] bl_reset br_reset gnd discharge_10
Xmod_113 bl[113] br[113] bl_reset br_reset gnd discharge_10
Xmod_114 bl[114] br[114] bl_reset br_reset gnd discharge_10
Xmod_115 bl[115] br[115] bl_reset br_reset gnd discharge_10
Xmod_116 bl[116] br[116] bl_reset br_reset gnd discharge_10
Xmod_117 bl[117] br[117] bl_reset br_reset gnd discharge_10
Xmod_118 bl[118] br[118] bl_reset br_reset gnd discharge_10
Xmod_119 bl[119] br[119] bl_reset br_reset gnd discharge_10
Xmod_120 bl[120] br[120] bl_reset br_reset gnd discharge_10
Xmod_121 bl[121] br[121] bl_reset br_reset gnd discharge_10
Xmod_122 bl[122] br[122] bl_reset br_reset gnd discharge_10
Xmod_123 bl[123] br[123] bl_reset br_reset gnd discharge_10
Xmod_124 bl[124] br[124] bl_reset br_reset gnd discharge_10
Xmod_125 bl[125] br[125] bl_reset br_reset gnd discharge_10
Xmod_126 bl[126] br[126] bl_reset br_reset gnd discharge_10
Xmod_127 bl[127] br[127] bl_reset br_reset gnd discharge_10
.ENDS precharge_array

.SUBCKT pnand2_1 A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pnand2_1

.SUBCKT pnand3_1 A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pnand3_1

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pnor2_1 A B Z vdd gnd
Xpmos1 vdd A net1 vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos2 net1 B Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos3 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
Xnmos4 Z B gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pnor2_1

.SUBCKT pinv_1 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1

.SUBCKT pinv_2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_2

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=2.31 l=0.15 pd=2.61 ps=2.61 as=0.433125 ad=0.433125

.SUBCKT pinv_2__56 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=2.31 l=0.15 pd=2.61 ps=2.61 as=0.433125 ad=0.433125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=0.93 l=0.15 pd=1.23 ps=1.23 as=0.174375 ad=0.174375
.ENDS pinv_2__56

.SUBCKT buffer_stage_2__56_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_2__56
.ENDS buffer_stage_2__56_no_out_h_4

.SUBCKT logic_buffer_pnand2_2_56_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B out_inv vdd gnd pnand2_1
Xbuffer out_inv out out_inv vdd gnd buffer_stage_2__56_no_out_h_4
.ENDS logic_buffer_pnand2_2_56_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=5.475 l=0.15 pd=3.9499999999999997 ps=3.9499999999999997 as=0.684375 ad=0.684375

.SUBCKT pinv_6__09 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=5.475 l=0.15 pd=3.9499999999999997 ps=3.9499999999999997 as=0.684375 ad=0.684375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=2.19 l=0.15 pd=1.76 ps=1.76 as=0.27375 ad=0.27375
.ENDS pinv_6__09

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=15 w=27.825 l=0.15 pd=4.01 ps=4.01 as=0.6956249999999999 ad=0.6956249999999999

.SUBCKT pinv_30__9 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=15 w=27.825 l=0.15 pd=4.01 ps=4.01 as=0.6956249999999999 ad=0.6956249999999999
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=15 w=11.1 l=0.15 pd=1.78 ps=1.78 as=0.27749999999999997 ad=0.27749999999999997
.ENDS pinv_30__9

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=29 w=53.940000000000005 l=0.15 pd=4.0200000000000005 ps=4.0200000000000005 as=0.6975 ad=0.6975

.SUBCKT pinv_60 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=29 w=53.940000000000005 l=0.15 pd=4.0200000000000005 ps=4.0200000000000005 as=0.6975 ad=0.6975
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=29 w=21.605 l=0.15 pd=1.79 ps=1.79 as=0.279375 ad=0.279375
.ENDS pinv_60

.SUBCKT buffer_stage_6__09_30__9_60_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_6__09
Xinv1 out_1 out vdd gnd pinv_30__9
Xinv2 out out_inv vdd gnd pinv_60
.ENDS buffer_stage_6__09_30__9_60_no_out_h_4

.SUBCKT logic_buffer_pnand2_6_09_30_9_60_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnand2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_6__09_30__9_60_no_out_h_4
.ENDS logic_buffer_pnand2_6_09_30_9_60_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.99 l=0.15 pd=2.96 ps=2.96 as=0.49875 ad=0.49875

.SUBCKT pinv_4__43 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.99 l=0.15 pd=2.96 ps=2.96 as=0.49875 ad=0.49875
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.59 l=0.15 pd=1.36 ps=1.36 as=0.19875 ad=0.19875
.ENDS pinv_4__43

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=9 w=15.615 l=0.15 pd=3.77 ps=3.77 as=0.650625 ad=0.650625

.SUBCKT pinv_17__3 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=9 w=15.615 l=0.15 pd=3.77 ps=3.77 as=0.650625 ad=0.650625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=9 w=6.255000000000001 l=0.15 pd=1.6900000000000002 ps=1.6900000000000002 as=0.260625 ad=0.260625
.ENDS pinv_17__3

.SUBCKT buffer_stage_4__43_17__3_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_4__43
Xinv1 out_inv out vdd gnd pinv_17__3
.ENDS buffer_stage_4__43_17__3_no_out_h_4

.SUBCKT logic_buffer_pnor2_4_43_17_3_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_4__43_17__3_no_out_h_4
.ENDS logic_buffer_pnor2_4_43_17_3_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=7.0 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625

.SUBCKT pinv_7__79 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=7.0 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.8000000000000003 l=0.15 pd=1.7000000000000002 ps=1.7000000000000002 as=0.2625 ad=0.2625
.ENDS pinv_7__79

.SUBCKT buffer_stage_7__79_60_60_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_7__79
Xinv1 out_1 out vdd gnd pinv_60
Xinv2 out out_inv vdd gnd pinv_60
.ENDS buffer_stage_7__79_60_60_no_out_h_4

.SUBCKT logic_buffer_pnor2_7_79_60_60_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_7__79_60_60_no_out_h_4
.ENDS logic_buffer_pnor2_7_79_60_60_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=5.68 l=0.15 pd=3.1399999999999997 ps=3.1399999999999997 as=0.5325 ad=0.5325

.SUBCKT pinv_6__31 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=5.68 l=0.15 pd=3.1399999999999997 ps=3.1399999999999997 as=0.5325 ad=0.5325
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.2800000000000002 l=0.15 pd=1.4400000000000002 ps=1.4400000000000002 as=0.21375000000000002 ad=0.21375000000000002
.ENDS pinv_6__31

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=19 w=35.245 l=0.15 pd=4.01 ps=4.01 as=0.6956249999999999 ad=0.6956249999999999

.SUBCKT pinv_39__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=19 w=35.245 l=0.15 pd=4.01 ps=4.01 as=0.6956249999999999 ad=0.6956249999999999
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=19 w=14.155 l=0.15 pd=1.79 ps=1.79 as=0.279375 ad=0.279375
.ENDS pinv_39__2

.SUBCKT buffer_stage_6__31_39__2_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_6__31
Xinv1 out_inv out vdd gnd pinv_39__2
.ENDS buffer_stage_6__31_39__2_no_out_h_4

.SUBCKT logic_buffer_pnor2_6_31_39_2_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_6__31_39__2_no_out_h_4
.ENDS logic_buffer_pnor2_6_31_39_2_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=5.505 l=0.15 pd=3.9699999999999998 ps=3.9699999999999998 as=0.688125 ad=0.688125

.SUBCKT pinv_6__12 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=5.505 l=0.15 pd=3.9699999999999998 ps=3.9699999999999998 as=0.688125 ad=0.688125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=2.205 l=0.15 pd=1.77 ps=1.77 as=0.275625 ad=0.275625
.ENDS pinv_6__12

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=14 w=24.78 l=0.15 pd=3.84 ps=3.84 as=0.6637500000000001 ad=0.6637500000000001

.SUBCKT pinv_27__5 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=14 w=24.78 l=0.15 pd=3.84 ps=3.84 as=0.6637500000000001 ad=0.6637500000000001
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=14 w=9.87 l=0.15 pd=1.71 ps=1.71 as=0.26437499999999997 ad=0.26437499999999997
.ENDS pinv_27__5

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=20 w=36.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pinv_40 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=20 w=36.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=20 w=14.399999999999999 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_40

.SUBCKT buffer_stage_6__12_27__5_40_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_6__12
Xinv1 out_1 out vdd gnd pinv_27__5
Xinv2 out out_inv vdd gnd pinv_40
.ENDS buffer_stage_6__12_27__5_40_no_out_h_4

.SUBCKT logic_buffer_pnand3_6_12_27_5_40_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_6__12_27__5_40_no_out_h_4
.ENDS logic_buffer_pnand3_6_12_27_5_40_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.5 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625

.SUBCKT pinv_3__88 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.5 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.4000000000000001 l=0.15 pd=1.7000000000000002 ps=1.7000000000000002 as=0.2625 ad=0.2625
.ENDS pinv_3__88

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=6 w=9.57 l=0.15 pd=3.4899999999999998 ps=3.4899999999999998 as=0.598125 ad=0.598125

.SUBCKT pinv_10__6 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=6 w=9.57 l=0.15 pd=3.4899999999999998 ps=3.4899999999999998 as=0.598125 ad=0.598125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=6 w=3.81 l=0.15 pd=1.57 ps=1.57 as=0.238125 ad=0.238125
.ENDS pinv_10__6

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=10 w=18.35 l=0.15 pd=3.9699999999999998 ps=3.9699999999999998 as=0.688125 ad=0.688125

.SUBCKT pinv_20__4 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=10 w=18.35 l=0.15 pd=3.9699999999999998 ps=3.9699999999999998 as=0.688125 ad=0.688125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=10 w=7.35 l=0.15 pd=1.77 ps=1.77 as=0.275625 ad=0.275625
.ENDS pinv_20__4

.SUBCKT buffer_stage_3__88_10__6_20__4_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_3__88
Xinv1 out_1 out vdd gnd pinv_10__6
Xinv2 out out_inv vdd gnd pinv_20__4
.ENDS buffer_stage_3__88_10__6_20__4_no_out_h_4

.SUBCKT logic_buffer_pnand3_3_88_10_6_20_4_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_3__88_10__6_20__4_no_out_h_4
.ENDS logic_buffer_pnand3_3_88_10_6_20_4_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=6.74 l=0.15 pd=3.67 ps=3.67 as=0.631875 ad=0.631875

.SUBCKT pinv_7__49 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=6.74 l=0.15 pd=3.67 ps=3.67 as=0.631875 ad=0.631875
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.7 l=0.15 pd=1.6500000000000001 ps=1.6500000000000001 as=0.25312500000000004 ad=0.25312500000000004
.ENDS pinv_7__49

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=13.055 l=0.15 pd=4.03 ps=4.03 as=0.699375 ad=0.699375

.SUBCKT pinv_14__5 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=13.055 l=0.15 pd=4.03 ps=4.03 as=0.699375 ad=0.699375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=5.215 l=0.15 pd=1.79 ps=1.79 as=0.279375 ad=0.279375
.ENDS pinv_14__5

.SUBCKT buffer_stage_7__49_14__5_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_7__49
Xinv1 out_inv out vdd gnd pinv_14__5
.ENDS buffer_stage_7__49_14__5_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=5 w=8.975 l=0.15 pd=3.8899999999999997 ps=3.8899999999999997 as=0.673125 ad=0.673125

.SUBCKT pinv_9__98 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=5 w=8.975 l=0.15 pd=3.8899999999999997 ps=3.8899999999999997 as=0.673125 ad=0.673125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=5 w=3.5999999999999996 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_9__98

.SUBCKT buffer_stage_9__98_40_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_9__98
Xinv1 out_inv out vdd gnd pinv_40
.ENDS buffer_stage_9__98_40_no_out_h_4

.SUBCKT logic_buffer_pnand3_9_98_40_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_9__98_40_no_out_h_4
.ENDS logic_buffer_pnand3_9_98_40_no_in_no_out_h_4

.SUBCKT control_buffers bank_sel read clk sense_trig decoder_clk clk_buf clk_bar wordline_en write_en write_en_bar sense_en tri_en tri_en_bar sample_en_bar bl_reset br_reset vdd gnd
Xdecoder_clk bank_sel clk decoder_clk_bar decoder_clk vdd gnd logic_buffer_pnand2_2_56_no_in_no_out_h_4
Xnor_read_clk read clk nor_read_clk vdd gnd pnor2_1
Xbr_reset nor_read_clk bank_sel_bar br_reset br_reset_bar vdd gnd logic_buffer_pnor2_6_31_39_2_no_in_no_out_h_4
Xclk_buf bank_sel clk clk_bar clk_buf vdd gnd logic_buffer_pnand2_6_09_30_9_60_no_in_no_out_h_4
Xwrite_buf read bank_sel_cbar write_en write_en_bar vdd gnd logic_buffer_pnor2_7_79_60_60_no_in_no_out_h_4
Xsense_amp_buf sample_bar_int sense_trig bank_sel sense_en_bar sense_en vdd gnd logic_buffer_pnand3_3_88_10_6_20_4_no_in_no_out_h_4
Xtri_en_buf sample_bar_int sense_trig bank_sel tri_en_bar tri_en vdd gnd logic_buffer_pnand3_9_98_40_no_in_no_out_h_4
Xsense_trig_bar sense_trig sense_trig_bar vdd gnd pinv_1
Xsample_bar_int bank_sel read sense_trig_bar sample_bar_int vdd gnd pnand3_1
Xsample_bar sample_bar_int sample_en_buf sample_en_bar vdd gnd buffer_stage_7__49_14__5_no_out_h_4
Xclk_bar clk clk_bar_int vdd gnd pinv_1
Xbank_sel_cbar bank_sel clk_bar_int bank_sel_cbar vdd gnd pnand2_1
Xwordline_buf sense_trig bank_sel_cbar wordline_en wordline_en_bar vdd gnd logic_buffer_pnor2_4_43_17_3_no_in_no_out_h_4
Xread_bar read read_bar vdd gnd pinv_1
Xbl_reset bank_sel clk read_bar bl_reset_bar bl_reset vdd gnd logic_buffer_pnand3_6_12_27_5_40_no_in_no_out_h_4
Xbank_sel_bar bank_sel bank_sel_bar vdd gnd pinv_1
.ENDS control_buffers

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=4.54 l=0.15 pd=2.57 ps=2.57 as=0.42562500000000003 ad=0.42562500000000003

.SUBCKT pinv_5__04_no_p_no_n_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=4.54 l=0.15 pd=2.57 ps=2.57 as=0.42562500000000003 ad=0.42562500000000003
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=1.82 l=0.15 pd=1.21 ps=1.21 as=0.170625 ad=0.170625
.ENDS pinv_5__04_no_p_no_n_h_3__2

.SUBCKT buffer_stage_5__04_no_out_no_nwell_cont_no_pwell_cont_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_5__04_no_p_no_n_h_3__2
.ENDS buffer_stage_5__04_no_out_no_nwell_cont_no_pwell_cont_h_3__2

.SUBCKT flop_buffer_5__04_neg din clk dout vdd gnd
Xflop din flop_out flop_out_bar clk vdd gnd ms_flop_horz_pitch
Xbuffer flop_out dout dout_bar vdd gnd buffer_stage_5__04_no_out_no_nwell_cont_no_pwell_cont_h_3__2
.ENDS flop_buffer_5__04_neg

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=2.7750000000000004 l=0.15 pd=2.15 ps=2.15 as=0.34687500000000004 ad=0.34687500000000004

.SUBCKT pinv_3__08_no_p_no_n_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=2.7750000000000004 l=0.15 pd=2.15 ps=2.15 as=0.34687500000000004 ad=0.34687500000000004
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.1099999999999999 l=0.15 pd=1.04 ps=1.04 as=0.13874999999999998 ad=0.13874999999999998
.ENDS pinv_3__08_no_p_no_n_h_3__2

.SUBCKT buffer_stage_3__08_no_out_no_nwell_cont_no_pwell_cont_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_3__08_no_p_no_n_h_3__2
.ENDS buffer_stage_3__08_no_out_no_nwell_cont_no_pwell_cont_h_3__2

.SUBCKT flop_buffer_3__08 din clk dout vdd gnd
Xflop din flop_out flop_out_bar clk vdd gnd ms_flop_horz_pitch
Xbuffer flop_out_bar dout dout_bar vdd gnd buffer_stage_3__08_no_out_no_nwell_cont_no_pwell_cont_h_3__2
.ENDS flop_buffer_3__08

.SUBCKT bank DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] DATA[32] MASK[32] DATA[33] MASK[33] DATA[34] MASK[34] DATA[35] MASK[35] DATA[36] MASK[36] DATA[37] MASK[37] DATA[38] MASK[38] DATA[39] MASK[39] DATA[40] MASK[40] DATA[41] MASK[41] DATA[42] MASK[42] DATA[43] MASK[43] DATA[44] MASK[44] DATA[45] MASK[45] DATA[46] MASK[46] DATA[47] MASK[47] DATA[48] MASK[48] DATA[49] MASK[49] DATA[50] MASK[50] DATA[51] MASK[51] DATA[52] MASK[52] DATA[53] MASK[53] DATA[54] MASK[54] DATA[55] MASK[55] DATA[56] MASK[56] DATA[57] MASK[57] DATA[58] MASK[58] DATA[59] MASK[59] DATA[60] MASK[60] DATA[61] MASK[61] DATA[62] MASK[62] DATA[63] MASK[63] sel[0] sel[1] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] dec_out[32] dec_out[33] dec_out[34] dec_out[35] dec_out[36] dec_out[37] dec_out[38] dec_out[39] dec_out[40] dec_out[41] dec_out[42] dec_out[43] dec_out[44] dec_out[45] dec_out[46] dec_out[47] dec_out[48] dec_out[49] dec_out[50] dec_out[51] dec_out[52] dec_out[53] dec_out[54] dec_out[55] dec_out[56] dec_out[57] dec_out[58] dec_out[59] dec_out[60] dec_out[61] dec_out[62] dec_out[63] Csb read clk sense_trig decoder_clk vdd gnd vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] vdd_write vdd_wordline
Xcontrol_buffers bank_sel_buf read_buf clk sense_trig decoder_clk clk_buf clk_bar wordline_en write_en write_en_bar sense_en tri_en tri_en_bar sample_en_bar bl_reset br_reset vdd gnd control_buffers
Xtri_gate_array sense_out_bar[0] sense_out_bar[1] sense_out_bar[2] sense_out_bar[3] sense_out_bar[4] sense_out_bar[5] sense_out_bar[6] sense_out_bar[7] sense_out_bar[8] sense_out_bar[9] sense_out_bar[10] sense_out_bar[11] sense_out_bar[12] sense_out_bar[13] sense_out_bar[14] sense_out_bar[15] sense_out_bar[16] sense_out_bar[17] sense_out_bar[18] sense_out_bar[19] sense_out_bar[20] sense_out_bar[21] sense_out_bar[22] sense_out_bar[23] sense_out_bar[24] sense_out_bar[25] sense_out_bar[26] sense_out_bar[27] sense_out_bar[28] sense_out_bar[29] sense_out_bar[30] sense_out_bar[31] sense_out_bar[32] sense_out_bar[33] sense_out_bar[34] sense_out_bar[35] sense_out_bar[36] sense_out_bar[37] sense_out_bar[38] sense_out_bar[39] sense_out_bar[40] sense_out_bar[41] sense_out_bar[42] sense_out_bar[43] sense_out_bar[44] sense_out_bar[45] sense_out_bar[46] sense_out_bar[47] sense_out_bar[48] sense_out_bar[49] sense_out_bar[50] sense_out_bar[51] sense_out_bar[52] sense_out_bar[53] sense_out_bar[54] sense_out_bar[55] sense_out_bar[56] sense_out_bar[57] sense_out_bar[58] sense_out_bar[59] sense_out_bar[60] sense_out_bar[61] sense_out_bar[62] sense_out_bar[63] DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] tri_en tri_en_bar vdd gnd tri_gate_array
Xmask_in MASK[0] MASK[1] MASK[2] MASK[3] MASK[4] MASK[5] MASK[6] MASK[7] MASK[8] MASK[9] MASK[10] MASK[11] MASK[12] MASK[13] MASK[14] MASK[15] MASK[16] MASK[17] MASK[18] MASK[19] MASK[20] MASK[21] MASK[22] MASK[23] MASK[24] MASK[25] MASK[26] MASK[27] MASK[28] MASK[29] MASK[30] MASK[31] MASK[32] MASK[33] MASK[34] MASK[35] MASK[36] MASK[37] MASK[38] MASK[39] MASK[40] MASK[41] MASK[42] MASK[43] MASK[44] MASK[45] MASK[46] MASK[47] MASK[48] MASK[49] MASK[50] MASK[51] MASK[52] MASK[53] MASK[54] MASK[55] MASK[56] MASK[57] MASK[58] MASK[59] MASK[60] MASK[61] MASK[62] MASK[63] mask_in[0] mask_in_bar[0] mask_in[1] mask_in_bar[1] mask_in[2] mask_in_bar[2] mask_in[3] mask_in_bar[3] mask_in[4] mask_in_bar[4] mask_in[5] mask_in_bar[5] mask_in[6] mask_in_bar[6] mask_in[7] mask_in_bar[7] mask_in[8] mask_in_bar[8] mask_in[9] mask_in_bar[9] mask_in[10] mask_in_bar[10] mask_in[11] mask_in_bar[11] mask_in[12] mask_in_bar[12] mask_in[13] mask_in_bar[13] mask_in[14] mask_in_bar[14] mask_in[15] mask_in_bar[15] mask_in[16] mask_in_bar[16] mask_in[17] mask_in_bar[17] mask_in[18] mask_in_bar[18] mask_in[19] mask_in_bar[19] mask_in[20] mask_in_bar[20] mask_in[21] mask_in_bar[21] mask_in[22] mask_in_bar[22] mask_in[23] mask_in_bar[23] mask_in[24] mask_in_bar[24] mask_in[25] mask_in_bar[25] mask_in[26] mask_in_bar[26] mask_in[27] mask_in_bar[27] mask_in[28] mask_in_bar[28] mask_in[29] mask_in_bar[29] mask_in[30] mask_in_bar[30] mask_in[31] mask_in_bar[31] mask_in[32] mask_in_bar[32] mask_in[33] mask_in_bar[33] mask_in[34] mask_in_bar[34] mask_in[35] mask_in_bar[35] mask_in[36] mask_in_bar[36] mask_in[37] mask_in_bar[37] mask_in[38] mask_in_bar[38] mask_in[39] mask_in_bar[39] mask_in[40] mask_in_bar[40] mask_in[41] mask_in_bar[41] mask_in[42] mask_in_bar[42] mask_in[43] mask_in_bar[43] mask_in[44] mask_in_bar[44] mask_in[45] mask_in_bar[45] mask_in[46] mask_in_bar[46] mask_in[47] mask_in_bar[47] mask_in[48] mask_in_bar[48] mask_in[49] mask_in_bar[49] mask_in[50] mask_in_bar[50] mask_in[51] mask_in_bar[51] mask_in[52] mask_in_bar[52] mask_in[53] mask_in_bar[53] mask_in[54] mask_in_bar[54] mask_in[55] mask_in_bar[55] mask_in[56] mask_in_bar[56] mask_in[57] mask_in_bar[57] mask_in[58] mask_in_bar[58] mask_in[59] mask_in_bar[59] mask_in[60] mask_in_bar[60] mask_in[61] mask_in_bar[61] mask_in[62] mask_in_bar[62] mask_in[63] mask_in_bar[63] clk_buf vdd gnd flop_array_c128_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap
Xdata_in DATA[0] DATA[1] DATA[2] DATA[3] DATA[4] DATA[5] DATA[6] DATA[7] DATA[8] DATA[9] DATA[10] DATA[11] DATA[12] DATA[13] DATA[14] DATA[15] DATA[16] DATA[17] DATA[18] DATA[19] DATA[20] DATA[21] DATA[22] DATA[23] DATA[24] DATA[25] DATA[26] DATA[27] DATA[28] DATA[29] DATA[30] DATA[31] DATA[32] DATA[33] DATA[34] DATA[35] DATA[36] DATA[37] DATA[38] DATA[39] DATA[40] DATA[41] DATA[42] DATA[43] DATA[44] DATA[45] DATA[46] DATA[47] DATA[48] DATA[49] DATA[50] DATA[51] DATA[52] DATA[53] DATA[54] DATA[55] DATA[56] DATA[57] DATA[58] DATA[59] DATA[60] DATA[61] DATA[62] DATA[63] data_in[0] data_in_bar[0] data_in[1] data_in_bar[1] data_in[2] data_in_bar[2] data_in[3] data_in_bar[3] data_in[4] data_in_bar[4] data_in[5] data_in_bar[5] data_in[6] data_in_bar[6] data_in[7] data_in_bar[7] data_in[8] data_in_bar[8] data_in[9] data_in_bar[9] data_in[10] data_in_bar[10] data_in[11] data_in_bar[11] data_in[12] data_in_bar[12] data_in[13] data_in_bar[13] data_in[14] data_in_bar[14] data_in[15] data_in_bar[15] data_in[16] data_in_bar[16] data_in[17] data_in_bar[17] data_in[18] data_in_bar[18] data_in[19] data_in_bar[19] data_in[20] data_in_bar[20] data_in[21] data_in_bar[21] data_in[22] data_in_bar[22] data_in[23] data_in_bar[23] data_in[24] data_in_bar[24] data_in[25] data_in_bar[25] data_in[26] data_in_bar[26] data_in[27] data_in_bar[27] data_in[28] data_in_bar[28] data_in[29] data_in_bar[29] data_in[30] data_in_bar[30] data_in[31] data_in_bar[31] data_in[32] data_in_bar[32] data_in[33] data_in_bar[33] data_in[34] data_in_bar[34] data_in[35] data_in_bar[35] data_in[36] data_in_bar[36] data_in[37] data_in_bar[37] data_in[38] data_in_bar[38] data_in[39] data_in_bar[39] data_in[40] data_in_bar[40] data_in[41] data_in_bar[41] data_in[42] data_in_bar[42] data_in[43] data_in_bar[43] data_in[44] data_in_bar[44] data_in[45] data_in_bar[45] data_in[46] data_in_bar[46] data_in[47] data_in_bar[47] data_in[48] data_in_bar[48] data_in[49] data_in_bar[49] data_in[50] data_in_bar[50] data_in[51] data_in_bar[51] data_in[52] data_in_bar[52] data_in[53] data_in_bar[53] data_in[54] data_in_bar[54] data_in[55] data_in_bar[55] data_in[56] data_in_bar[56] data_in[57] data_in_bar[57] data_in[58] data_in_bar[58] data_in[59] data_in_bar[59] data_in[60] data_in_bar[60] data_in[61] data_in_bar[61] data_in[62] data_in_bar[62] data_in[63] data_in_bar[63] clk_bar vdd gnd flop_array_c128_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap
Xwrite_driver_array data_in[0] data_in_bar[0] data_in[1] data_in_bar[1] data_in[2] data_in_bar[2] data_in[3] data_in_bar[3] data_in[4] data_in_bar[4] data_in[5] data_in_bar[5] data_in[6] data_in_bar[6] data_in[7] data_in_bar[7] data_in[8] data_in_bar[8] data_in[9] data_in_bar[9] data_in[10] data_in_bar[10] data_in[11] data_in_bar[11] data_in[12] data_in_bar[12] data_in[13] data_in_bar[13] data_in[14] data_in_bar[14] data_in[15] data_in_bar[15] data_in[16] data_in_bar[16] data_in[17] data_in_bar[17] data_in[18] data_in_bar[18] data_in[19] data_in_bar[19] data_in[20] data_in_bar[20] data_in[21] data_in_bar[21] data_in[22] data_in_bar[22] data_in[23] data_in_bar[23] data_in[24] data_in_bar[24] data_in[25] data_in_bar[25] data_in[26] data_in_bar[26] data_in[27] data_in_bar[27] data_in[28] data_in_bar[28] data_in[29] data_in_bar[29] data_in[30] data_in_bar[30] data_in[31] data_in_bar[31] data_in[32] data_in_bar[32] data_in[33] data_in_bar[33] data_in[34] data_in_bar[34] data_in[35] data_in_bar[35] data_in[36] data_in_bar[36] data_in[37] data_in_bar[37] data_in[38] data_in_bar[38] data_in[39] data_in_bar[39] data_in[40] data_in_bar[40] data_in[41] data_in_bar[41] data_in[42] data_in_bar[42] data_in[43] data_in_bar[43] data_in[44] data_in_bar[44] data_in[45] data_in_bar[45] data_in[46] data_in_bar[46] data_in[47] data_in_bar[47] data_in[48] data_in_bar[48] data_in[49] data_in_bar[49] data_in[50] data_in_bar[50] data_in[51] data_in_bar[51] data_in[52] data_in_bar[52] data_in[53] data_in_bar[53] data_in[54] data_in_bar[54] data_in[55] data_in_bar[55] data_in[56] data_in_bar[56] data_in[57] data_in_bar[57] data_in[58] data_in_bar[58] data_in[59] data_in_bar[59] data_in[60] data_in_bar[60] data_in[61] data_in_bar[61] data_in[62] data_in_bar[62] data_in[63] data_in_bar[63] bl_out[0] br_out[0] bl_out[1] br_out[1] bl_out[2] br_out[2] bl_out[3] br_out[3] bl_out[4] br_out[4] bl_out[5] br_out[5] bl_out[6] br_out[6] bl_out[7] br_out[7] bl_out[8] br_out[8] bl_out[9] br_out[9] bl_out[10] br_out[10] bl_out[11] br_out[11] bl_out[12] br_out[12] bl_out[13] br_out[13] bl_out[14] br_out[14] bl_out[15] br_out[15] bl_out[16] br_out[16] bl_out[17] br_out[17] bl_out[18] br_out[18] bl_out[19] br_out[19] bl_out[20] br_out[20] bl_out[21] br_out[21] bl_out[22] br_out[22] bl_out[23] br_out[23] bl_out[24] br_out[24] bl_out[25] br_out[25] bl_out[26] br_out[26] bl_out[27] br_out[27] bl_out[28] br_out[28] bl_out[29] br_out[29] bl_out[30] br_out[30] bl_out[31] br_out[31] bl_out[32] br_out[32] bl_out[33] br_out[33] bl_out[34] br_out[34] bl_out[35] br_out[35] bl_out[36] br_out[36] bl_out[37] br_out[37] bl_out[38] br_out[38] bl_out[39] br_out[39] bl_out[40] br_out[40] bl_out[41] br_out[41] bl_out[42] br_out[42] bl_out[43] br_out[43] bl_out[44] br_out[44] bl_out[45] br_out[45] bl_out[46] br_out[46] bl_out[47] br_out[47] bl_out[48] br_out[48] bl_out[49] br_out[49] bl_out[50] br_out[50] bl_out[51] br_out[51] bl_out[52] br_out[52] bl_out[53] br_out[53] bl_out[54] br_out[54] bl_out[55] br_out[55] bl_out[56] br_out[56] bl_out[57] br_out[57] bl_out[58] br_out[58] bl_out[59] br_out[59] bl_out[60] br_out[60] bl_out[61] br_out[61] bl_out[62] br_out[62] bl_out[63] br_out[63] mask_in_bar[0] mask_in_bar[1] mask_in_bar[2] mask_in_bar[3] mask_in_bar[4] mask_in_bar[5] mask_in_bar[6] mask_in_bar[7] mask_in_bar[8] mask_in_bar[9] mask_in_bar[10] mask_in_bar[11] mask_in_bar[12] mask_in_bar[13] mask_in_bar[14] mask_in_bar[15] mask_in_bar[16] mask_in_bar[17] mask_in_bar[18] mask_in_bar[19] mask_in_bar[20] mask_in_bar[21] mask_in_bar[22] mask_in_bar[23] mask_in_bar[24] mask_in_bar[25] mask_in_bar[26] mask_in_bar[27] mask_in_bar[28] mask_in_bar[29] mask_in_bar[30] mask_in_bar[31] mask_in_bar[32] mask_in_bar[33] mask_in_bar[34] mask_in_bar[35] mask_in_bar[36] mask_in_bar[37] mask_in_bar[38] mask_in_bar[39] mask_in_bar[40] mask_in_bar[41] mask_in_bar[42] mask_in_bar[43] mask_in_bar[44] mask_in_bar[45] mask_in_bar[46] mask_in_bar[47] mask_in_bar[48] mask_in_bar[49] mask_in_bar[50] mask_in_bar[51] mask_in_bar[52] mask_in_bar[53] mask_in_bar[54] mask_in_bar[55] mask_in_bar[56] mask_in_bar[57] mask_in_bar[58] mask_in_bar[59] mask_in_bar[60] mask_in_bar[61] mask_in_bar[62] mask_in_bar[63] write_en write_en_bar vdd_write gnd write_driver_array
Xsense_amp_array bl_out[0] bl_out[1] bl_out[2] bl_out[3] bl_out[4] bl_out[5] bl_out[6] bl_out[7] bl_out[8] bl_out[9] bl_out[10] bl_out[11] bl_out[12] bl_out[13] bl_out[14] bl_out[15] bl_out[16] bl_out[17] bl_out[18] bl_out[19] bl_out[20] bl_out[21] bl_out[22] bl_out[23] bl_out[24] bl_out[25] bl_out[26] bl_out[27] bl_out[28] bl_out[29] bl_out[30] bl_out[31] bl_out[32] bl_out[33] bl_out[34] bl_out[35] bl_out[36] bl_out[37] bl_out[38] bl_out[39] bl_out[40] bl_out[41] bl_out[42] bl_out[43] bl_out[44] bl_out[45] bl_out[46] bl_out[47] bl_out[48] bl_out[49] bl_out[50] bl_out[51] bl_out[52] bl_out[53] bl_out[54] bl_out[55] bl_out[56] bl_out[57] bl_out[58] bl_out[59] bl_out[60] bl_out[61] bl_out[62] bl_out[63] br_out[0] br_out[1] br_out[2] br_out[3] br_out[4] br_out[5] br_out[6] br_out[7] br_out[8] br_out[9] br_out[10] br_out[11] br_out[12] br_out[13] br_out[14] br_out[15] br_out[16] br_out[17] br_out[18] br_out[19] br_out[20] br_out[21] br_out[22] br_out[23] br_out[24] br_out[25] br_out[26] br_out[27] br_out[28] br_out[29] br_out[30] br_out[31] br_out[32] br_out[33] br_out[34] br_out[35] br_out[36] br_out[37] br_out[38] br_out[39] br_out[40] br_out[41] br_out[42] br_out[43] br_out[44] br_out[45] br_out[46] br_out[47] br_out[48] br_out[49] br_out[50] br_out[51] br_out[52] br_out[53] br_out[54] br_out[55] br_out[56] br_out[57] br_out[58] br_out[59] br_out[60] br_out[61] br_out[62] br_out[63] sense_out[0] sense_out[1] sense_out[2] sense_out[3] sense_out[4] sense_out[5] sense_out[6] sense_out[7] sense_out[8] sense_out[9] sense_out[10] sense_out[11] sense_out[12] sense_out[13] sense_out[14] sense_out[15] sense_out[16] sense_out[17] sense_out[18] sense_out[19] sense_out[20] sense_out[21] sense_out[22] sense_out[23] sense_out[24] sense_out[25] sense_out[26] sense_out[27] sense_out[28] sense_out[29] sense_out[30] sense_out[31] sense_out[32] sense_out[33] sense_out[34] sense_out[35] sense_out[36] sense_out[37] sense_out[38] sense_out[39] sense_out[40] sense_out[41] sense_out[42] sense_out[43] sense_out[44] sense_out[45] sense_out[46] sense_out[47] sense_out[48] sense_out[49] sense_out[50] sense_out[51] sense_out[52] sense_out[53] sense_out[54] sense_out[55] sense_out[56] sense_out[57] sense_out[58] sense_out[59] sense_out[60] sense_out[61] sense_out[62] sense_out[63] sense_out_bar[0] sense_out_bar[1] sense_out_bar[2] sense_out_bar[3] sense_out_bar[4] sense_out_bar[5] sense_out_bar[6] sense_out_bar[7] sense_out_bar[8] sense_out_bar[9] sense_out_bar[10] sense_out_bar[11] sense_out_bar[12] sense_out_bar[13] sense_out_bar[14] sense_out_bar[15] sense_out_bar[16] sense_out_bar[17] sense_out_bar[18] sense_out_bar[19] sense_out_bar[20] sense_out_bar[21] sense_out_bar[22] sense_out_bar[23] sense_out_bar[24] sense_out_bar[25] sense_out_bar[26] sense_out_bar[27] sense_out_bar[28] sense_out_bar[29] sense_out_bar[30] sense_out_bar[31] sense_out_bar[32] sense_out_bar[33] sense_out_bar[34] sense_out_bar[35] sense_out_bar[36] sense_out_bar[37] sense_out_bar[38] sense_out_bar[39] sense_out_bar[40] sense_out_bar[41] sense_out_bar[42] sense_out_bar[43] sense_out_bar[44] sense_out_bar[45] sense_out_bar[46] sense_out_bar[47] sense_out_bar[48] sense_out_bar[49] sense_out_bar[50] sense_out_bar[51] sense_out_bar[52] sense_out_bar[53] sense_out_bar[54] sense_out_bar[55] sense_out_bar[56] sense_out_bar[57] sense_out_bar[58] sense_out_bar[59] sense_out_bar[60] sense_out_bar[61] sense_out_bar[62] sense_out_bar[63] sense_en gnd sample_en_bar vclamp vclampp vdd vref sense_amp_array
Xcolumn_mux_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] bl[64] br[64] bl[65] br[65] bl[66] br[66] bl[67] br[67] bl[68] br[68] bl[69] br[69] bl[70] br[70] bl[71] br[71] bl[72] br[72] bl[73] br[73] bl[74] br[74] bl[75] br[75] bl[76] br[76] bl[77] br[77] bl[78] br[78] bl[79] br[79] bl[80] br[80] bl[81] br[81] bl[82] br[82] bl[83] br[83] bl[84] br[84] bl[85] br[85] bl[86] br[86] bl[87] br[87] bl[88] br[88] bl[89] br[89] bl[90] br[90] bl[91] br[91] bl[92] br[92] bl[93] br[93] bl[94] br[94] bl[95] br[95] bl[96] br[96] bl[97] br[97] bl[98] br[98] bl[99] br[99] bl[100] br[100] bl[101] br[101] bl[102] br[102] bl[103] br[103] bl[104] br[104] bl[105] br[105] bl[106] br[106] bl[107] br[107] bl[108] br[108] bl[109] br[109] bl[110] br[110] bl[111] br[111] bl[112] br[112] bl[113] br[113] bl[114] br[114] bl[115] br[115] bl[116] br[116] bl[117] br[117] bl[118] br[118] bl[119] br[119] bl[120] br[120] bl[121] br[121] bl[122] br[122] bl[123] br[123] bl[124] br[124] bl[125] br[125] bl[126] br[126] bl[127] br[127] sel[0] sel[1] bl_out[0] br_out[0] bl_out[1] br_out[1] bl_out[2] br_out[2] bl_out[3] br_out[3] bl_out[4] br_out[4] bl_out[5] br_out[5] bl_out[6] br_out[6] bl_out[7] br_out[7] bl_out[8] br_out[8] bl_out[9] br_out[9] bl_out[10] br_out[10] bl_out[11] br_out[11] bl_out[12] br_out[12] bl_out[13] br_out[13] bl_out[14] br_out[14] bl_out[15] br_out[15] bl_out[16] br_out[16] bl_out[17] br_out[17] bl_out[18] br_out[18] bl_out[19] br_out[19] bl_out[20] br_out[20] bl_out[21] br_out[21] bl_out[22] br_out[22] bl_out[23] br_out[23] bl_out[24] br_out[24] bl_out[25] br_out[25] bl_out[26] br_out[26] bl_out[27] br_out[27] bl_out[28] br_out[28] bl_out[29] br_out[29] bl_out[30] br_out[30] bl_out[31] br_out[31] bl_out[32] br_out[32] bl_out[33] br_out[33] bl_out[34] br_out[34] bl_out[35] br_out[35] bl_out[36] br_out[36] bl_out[37] br_out[37] bl_out[38] br_out[38] bl_out[39] br_out[39] bl_out[40] br_out[40] bl_out[41] br_out[41] bl_out[42] br_out[42] bl_out[43] br_out[43] bl_out[44] br_out[44] bl_out[45] br_out[45] bl_out[46] br_out[46] bl_out[47] br_out[47] bl_out[48] br_out[48] bl_out[49] br_out[49] bl_out[50] br_out[50] bl_out[51] br_out[51] bl_out[52] br_out[52] bl_out[53] br_out[53] bl_out[54] br_out[54] bl_out[55] br_out[55] bl_out[56] br_out[56] bl_out[57] br_out[57] bl_out[58] br_out[58] bl_out[59] br_out[59] bl_out[60] br_out[60] bl_out[61] br_out[61] bl_out[62] br_out[62] bl_out[63] br_out[63] vdd gnd columnmux_array
Xprecharge_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] bl[32] bl[33] bl[34] bl[35] bl[36] bl[37] bl[38] bl[39] bl[40] bl[41] bl[42] bl[43] bl[44] bl[45] bl[46] bl[47] bl[48] bl[49] bl[50] bl[51] bl[52] bl[53] bl[54] bl[55] bl[56] bl[57] bl[58] bl[59] bl[60] bl[61] bl[62] bl[63] bl[64] bl[65] bl[66] bl[67] bl[68] bl[69] bl[70] bl[71] bl[72] bl[73] bl[74] bl[75] bl[76] bl[77] bl[78] bl[79] bl[80] bl[81] bl[82] bl[83] bl[84] bl[85] bl[86] bl[87] bl[88] bl[89] bl[90] bl[91] bl[92] bl[93] bl[94] bl[95] bl[96] bl[97] bl[98] bl[99] bl[100] bl[101] bl[102] bl[103] bl[104] bl[105] bl[106] bl[107] bl[108] bl[109] bl[110] bl[111] bl[112] bl[113] bl[114] bl[115] bl[116] bl[117] bl[118] bl[119] bl[120] bl[121] bl[122] bl[123] bl[124] bl[125] bl[126] bl[127] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] br[32] br[33] br[34] br[35] br[36] br[37] br[38] br[39] br[40] br[41] br[42] br[43] br[44] br[45] br[46] br[47] br[48] br[49] br[50] br[51] br[52] br[53] br[54] br[55] br[56] br[57] br[58] br[59] br[60] br[61] br[62] br[63] br[64] br[65] br[66] br[67] br[68] br[69] br[70] br[71] br[72] br[73] br[74] br[75] br[76] br[77] br[78] br[79] br[80] br[81] br[82] br[83] br[84] br[85] br[86] br[87] br[88] br[89] br[90] br[91] br[92] br[93] br[94] br[95] br[96] br[97] br[98] br[99] br[100] br[101] br[102] br[103] br[104] br[105] br[106] br[107] br[108] br[109] br[110] br[111] br[112] br[113] br[114] br[115] br[116] br[117] br[118] br[119] br[120] br[121] br[122] br[123] br[124] br[125] br[126] br[127] bl_reset br_reset gnd precharge_array
Xbitcell_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] bl[64] br[64] bl[65] br[65] bl[66] br[66] bl[67] br[67] bl[68] br[68] bl[69] br[69] bl[70] br[70] bl[71] br[71] bl[72] br[72] bl[73] br[73] bl[74] br[74] bl[75] br[75] bl[76] br[76] bl[77] br[77] bl[78] br[78] bl[79] br[79] bl[80] br[80] bl[81] br[81] bl[82] br[82] bl[83] br[83] bl[84] br[84] bl[85] br[85] bl[86] br[86] bl[87] br[87] bl[88] br[88] bl[89] br[89] bl[90] br[90] bl[91] br[91] bl[92] br[92] bl[93] br[93] bl[94] br[94] bl[95] br[95] bl[96] br[96] bl[97] br[97] bl[98] br[98] bl[99] br[99] bl[100] br[100] bl[101] br[101] bl[102] br[102] bl[103] br[103] bl[104] br[104] bl[105] br[105] bl[106] br[106] bl[107] br[107] bl[108] br[108] bl[109] br[109] bl[110] br[110] bl[111] br[111] bl[112] br[112] bl[113] br[113] bl[114] br[114] bl[115] br[115] bl[116] br[116] bl[117] br[117] bl[118] br[118] bl[119] br[119] bl[120] br[120] bl[121] br[121] bl[122] br[122] bl[123] br[123] bl[124] br[124] bl[125] br[125] bl[126] br[126] bl[127] br[127] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] wl[32] wl[33] wl[34] wl[35] wl[36] wl[37] wl[38] wl[39] wl[40] wl[41] wl[42] wl[43] wl[44] wl[45] wl[46] wl[47] wl[48] wl[49] wl[50] wl[51] wl[52] wl[53] wl[54] wl[55] wl[56] wl[57] wl[58] wl[59] wl[60] wl[61] wl[62] wl[63] vdd gnd bitcell_array
Xwordline_driver dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] dec_out[32] dec_out[33] dec_out[34] dec_out[35] dec_out[36] dec_out[37] dec_out[38] dec_out[39] dec_out[40] dec_out[41] dec_out[42] dec_out[43] dec_out[44] dec_out[45] dec_out[46] dec_out[47] dec_out[48] dec_out[49] dec_out[50] dec_out[51] dec_out[52] dec_out[53] dec_out[54] dec_out[55] dec_out[56] dec_out[57] dec_out[58] dec_out[59] dec_out[60] dec_out[61] dec_out[62] dec_out[63] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] wl[32] wl[33] wl[34] wl[35] wl[36] wl[37] wl[38] wl[39] wl[40] wl[41] wl[42] wl[43] wl[44] wl[45] wl[46] wl[47] wl[48] wl[49] wl[50] wl[51] wl[52] wl[53] wl[54] wl[55] wl[56] wl[57] wl[58] wl[59] wl[60] wl[61] wl[62] wl[63] wordline_en vdd_wordline gnd wordline_driver_array
Xbank_sel_buf Csb clk bank_sel_buf vdd gnd flop_buffer_5__04_neg
Xread_buf read clk read_buf vdd gnd flop_buffer_3__08
.ENDS bank

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=6 w=7.199999999999999 l=0.15 pd=2.6999999999999997 ps=2.6999999999999997 as=0.44999999999999996 ad=0.44999999999999996

.SUBCKT pinv_8_no_p_no_n_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=6 w=7.199999999999999 l=0.15 pd=2.6999999999999997 ps=2.6999999999999997 as=0.44999999999999996 ad=0.44999999999999996
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=6 w=2.88 l=0.15 pd=1.26 ps=1.26 as=0.18 ad=0.18
.ENDS pinv_8_no_p_no_n_h_3__2

.SUBCKT buffer_stage_8_8_no_out_no_nwell_cont_no_pwell_cont_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_8_no_p_no_n_h_3__2
Xinv1 out_inv out vdd gnd pinv_8_no_p_no_n_h_3__2
.ENDS buffer_stage_8_8_no_out_no_nwell_cont_no_pwell_cont_h_3__2

.SUBCKT flop_buffer_8_8 din dout_bar dout clk vdd gnd
Xflop din flop_out flop_out_bar clk vdd gnd ms_flop_horz_pitch
Xbuffer flop_out dout_bar dout vdd gnd buffer_stage_8_8_no_out_no_nwell_cont_no_pwell_cont_h_3__2
.ENDS flop_buffer_8_8

.SUBCKT r_64_w_64_wpr_2 DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] DATA[32] MASK[32] DATA[33] MASK[33] DATA[34] MASK[34] DATA[35] MASK[35] DATA[36] MASK[36] DATA[37] MASK[37] DATA[38] MASK[38] DATA[39] MASK[39] DATA[40] MASK[40] DATA[41] MASK[41] DATA[42] MASK[42] DATA[43] MASK[43] DATA[44] MASK[44] DATA[45] MASK[45] DATA[46] MASK[46] DATA[47] MASK[47] DATA[48] MASK[48] DATA[49] MASK[49] DATA[50] MASK[50] DATA[51] MASK[51] DATA[52] MASK[52] DATA[53] MASK[53] DATA[54] MASK[54] DATA[55] MASK[55] DATA[56] MASK[56] DATA[57] MASK[57] DATA[58] MASK[58] DATA[59] MASK[59] DATA[60] MASK[60] DATA[61] MASK[61] DATA[62] MASK[62] DATA[63] MASK[63] Csb Web clk sense_trig vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] vdd_write vdd_wordline ADDR[1] ADDR[2] ADDR[3] ADDR[4] ADDR[5] ADDR[6] ADDR[0] vdd gnd
Xbank0 DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] DATA[32] MASK[32] DATA[33] MASK[33] DATA[34] MASK[34] DATA[35] MASK[35] DATA[36] MASK[36] DATA[37] MASK[37] DATA[38] MASK[38] DATA[39] MASK[39] DATA[40] MASK[40] DATA[41] MASK[41] DATA[42] MASK[42] DATA[43] MASK[43] DATA[44] MASK[44] DATA[45] MASK[45] DATA[46] MASK[46] DATA[47] MASK[47] DATA[48] MASK[48] DATA[49] MASK[49] DATA[50] MASK[50] DATA[51] MASK[51] DATA[52] MASK[52] DATA[53] MASK[53] DATA[54] MASK[54] DATA[55] MASK[55] DATA[56] MASK[56] DATA[57] MASK[57] DATA[58] MASK[58] DATA[59] MASK[59] DATA[60] MASK[60] DATA[61] MASK[61] DATA[62] MASK[62] DATA[63] MASK[63] sel[0] sel[1] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] dec_out[32] dec_out[33] dec_out[34] dec_out[35] dec_out[36] dec_out[37] dec_out[38] dec_out[39] dec_out[40] dec_out[41] dec_out[42] dec_out[43] dec_out[44] dec_out[45] dec_out[46] dec_out[47] dec_out[48] dec_out[49] dec_out[50] dec_out[51] dec_out[52] dec_out[53] dec_out[54] dec_out[55] dec_out[56] dec_out[57] dec_out[58] dec_out[59] dec_out[60] dec_out[61] dec_out[62] dec_out[63] Csb Web clk sense_trig decoder_clk vdd gnd vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] vdd_write vdd_wordline bank
Xrow_decoder ADDR[1] ADDR[2] ADDR[3] ADDR[4] ADDR[5] ADDR[6] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] dec_out[32] dec_out[33] dec_out[34] dec_out[35] dec_out[36] dec_out[37] dec_out[38] dec_out[39] dec_out[40] dec_out[41] dec_out[42] dec_out[43] dec_out[44] dec_out[45] dec_out[46] dec_out[47] dec_out[48] dec_out[49] dec_out[50] dec_out[51] dec_out[52] dec_out[53] dec_out[54] dec_out[55] dec_out[56] dec_out[57] dec_out[58] dec_out[59] dec_out[60] dec_out[61] dec_out[62] dec_out[63] decoder_clk vdd gnd hierarchical_decoder_64rows
Xcol_decoder ADDR[0] sel[0] sel[1] decoder_clk vdd gnd flop_buffer_8_8
.ENDS r_64_w_64_wpr_2
