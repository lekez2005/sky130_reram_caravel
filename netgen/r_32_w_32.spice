*FIRST LINE IS A COMMENT

.SUBCKT reram_bitcell_7 bl br wl gnd
Xaccess be wl br gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=7.0 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625
Xmem bl be sky130_fd_pr__reram_reram_cell
.ENDS reram_bitcell_7
.subckt ms_flop_clk_buf din dout dout_bar clk vdd gnd
xm1 clk_buf clk_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 clk_buf clk_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 clk_bar clk gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm3 clk_bar clk vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 din clk_buf vdd gnd lout lout_bar clk_bar dlatch
x2 lout_bar clk_bar vdd gnd dout_bar dout clk_buf dlatch
.ends
.subckt dlatch  din clk vdd gnd dout dout_bar clk_bar
xm1 dout dout_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 dout_bar int gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 int clk dout gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 int clk_bar dout vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 int clk_bar din gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 int clk din vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout_bar int vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 dout dout_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

.SUBCKT flop_array_c32_w32_ms_flop_clk_buf_ms_flop_clk_buf_tap din[0] din[1] din[2] din[3] din[4] din[5] din[6] din[7] din[8] din[9] din[10] din[11] din[12] din[13] din[14] din[15] din[16] din[17] din[18] din[19] din[20] din[21] din[22] din[23] din[24] din[25] din[26] din[27] din[28] din[29] din[30] din[31] dout[0] dout_bar[0] dout[1] dout_bar[1] dout[2] dout_bar[2] dout[3] dout_bar[3] dout[4] dout_bar[4] dout[5] dout_bar[5] dout[6] dout_bar[6] dout[7] dout_bar[7] dout[8] dout_bar[8] dout[9] dout_bar[9] dout[10] dout_bar[10] dout[11] dout_bar[11] dout[12] dout_bar[12] dout[13] dout_bar[13] dout[14] dout_bar[14] dout[15] dout_bar[15] dout[16] dout_bar[16] dout[17] dout_bar[17] dout[18] dout_bar[18] dout[19] dout_bar[19] dout[20] dout_bar[20] dout[21] dout_bar[21] dout[22] dout_bar[22] dout[23] dout_bar[23] dout[24] dout_bar[24] dout[25] dout_bar[25] dout[26] dout_bar[26] dout[27] dout_bar[27] dout[28] dout_bar[28] dout[29] dout_bar[29] dout[30] dout_bar[30] dout[31] dout_bar[31] clk vdd gnd
Xmod_0 din[0] dout[0] dout_bar[0] clk vdd gnd ms_flop_clk_buf
Xmod_1 din[1] dout[1] dout_bar[1] clk vdd gnd ms_flop_clk_buf
Xmod_2 din[2] dout[2] dout_bar[2] clk vdd gnd ms_flop_clk_buf
Xmod_3 din[3] dout[3] dout_bar[3] clk vdd gnd ms_flop_clk_buf
Xmod_4 din[4] dout[4] dout_bar[4] clk vdd gnd ms_flop_clk_buf
Xmod_5 din[5] dout[5] dout_bar[5] clk vdd gnd ms_flop_clk_buf
Xmod_6 din[6] dout[6] dout_bar[6] clk vdd gnd ms_flop_clk_buf
Xmod_7 din[7] dout[7] dout_bar[7] clk vdd gnd ms_flop_clk_buf
Xmod_8 din[8] dout[8] dout_bar[8] clk vdd gnd ms_flop_clk_buf
Xmod_9 din[9] dout[9] dout_bar[9] clk vdd gnd ms_flop_clk_buf
Xmod_10 din[10] dout[10] dout_bar[10] clk vdd gnd ms_flop_clk_buf
Xmod_11 din[11] dout[11] dout_bar[11] clk vdd gnd ms_flop_clk_buf
Xmod_12 din[12] dout[12] dout_bar[12] clk vdd gnd ms_flop_clk_buf
Xmod_13 din[13] dout[13] dout_bar[13] clk vdd gnd ms_flop_clk_buf
Xmod_14 din[14] dout[14] dout_bar[14] clk vdd gnd ms_flop_clk_buf
Xmod_15 din[15] dout[15] dout_bar[15] clk vdd gnd ms_flop_clk_buf
Xmod_16 din[16] dout[16] dout_bar[16] clk vdd gnd ms_flop_clk_buf
Xmod_17 din[17] dout[17] dout_bar[17] clk vdd gnd ms_flop_clk_buf
Xmod_18 din[18] dout[18] dout_bar[18] clk vdd gnd ms_flop_clk_buf
Xmod_19 din[19] dout[19] dout_bar[19] clk vdd gnd ms_flop_clk_buf
Xmod_20 din[20] dout[20] dout_bar[20] clk vdd gnd ms_flop_clk_buf
Xmod_21 din[21] dout[21] dout_bar[21] clk vdd gnd ms_flop_clk_buf
Xmod_22 din[22] dout[22] dout_bar[22] clk vdd gnd ms_flop_clk_buf
Xmod_23 din[23] dout[23] dout_bar[23] clk vdd gnd ms_flop_clk_buf
Xmod_24 din[24] dout[24] dout_bar[24] clk vdd gnd ms_flop_clk_buf
Xmod_25 din[25] dout[25] dout_bar[25] clk vdd gnd ms_flop_clk_buf
Xmod_26 din[26] dout[26] dout_bar[26] clk vdd gnd ms_flop_clk_buf
Xmod_27 din[27] dout[27] dout_bar[27] clk vdd gnd ms_flop_clk_buf
Xmod_28 din[28] dout[28] dout_bar[28] clk vdd gnd ms_flop_clk_buf
Xmod_29 din[29] dout[29] dout_bar[29] clk vdd gnd ms_flop_clk_buf
Xmod_30 din[30] dout[30] dout_bar[30] clk vdd gnd ms_flop_clk_buf
Xmod_31 din[31] dout[31] dout_bar[31] clk vdd gnd ms_flop_clk_buf
.ENDS flop_array_c32_w32_ms_flop_clk_buf_ms_flop_clk_buf_tap
.subckt write_driver_mux_logic mask en data data_bar bl_p bl_n br_p br_n gnd vdd
xm4 mask_en_bar en net1 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm1 net1 mask gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm2 mask_en_bar en vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 mask_en_bar mask vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm5 mask_en mask_en_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm7 br_p data_bar net2 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 net2 mask_en gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm9 br_p data_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm10 br_p mask_en vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm11 bl_p data net3 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm12 net3 mask_en gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm13 bl_p data vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm14 bl_p mask_en vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm16 br_n mask_en_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm18 br_n data_bar net4 vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.8 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm15 br_n data_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm17 net4 mask_en_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.8 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm19 bl_n mask_en_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm20 bl_n data net5 vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.8 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm21 bl_n data gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm22 net5 mask_en_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.8 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm6 mask_en mask_en_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.5 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=9.0 l=0.15 pd=9.3 ps=9.3 as=1.6875 ad=1.6875

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=9.0 l=0.15 pd=9.3 ps=9.3 as=1.6875 ad=1.6875

.SUBCKT write_driver_sep_vdd_10 data data_bar mask en bl br vdd vdd_write_bl vdd_write_br gnd
Xlogic mask en data data_bar bl_p bl_n br_p br_n gnd vdd write_driver_mux_logic
Xbl_nmos bl bl_n gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xbr_nmos br br_n gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xbl_pmos bl bl_p vdd_write_bl vdd_write_bl sky130_fd_pr__pfet_01v8 m=1 nf=2 w=9.0 l=0.15 pd=9.3 ps=9.3 as=1.6875 ad=1.6875
Xbr_pmos br br_p vdd_write_br vdd_write_bl sky130_fd_pr__pfet_01v8 m=1 nf=2 w=9.0 l=0.15 pd=9.3 ps=9.3 as=1.6875 ad=1.6875
.ENDS write_driver_sep_vdd_10

.SUBCKT write_driver_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] data[0] data[1] data[2] data[3] data[4] data[5] data[6] data[7] data[8] data[9] data[10] data[11] data[12] data[13] data[14] data[15] data[16] data[17] data[18] data[19] data[20] data[21] data[22] data[23] data[24] data[25] data[26] data[27] data[28] data[29] data[30] data[31] data_bar[0] data_bar[1] data_bar[2] data_bar[3] data_bar[4] data_bar[5] data_bar[6] data_bar[7] data_bar[8] data_bar[9] data_bar[10] data_bar[11] data_bar[12] data_bar[13] data_bar[14] data_bar[15] data_bar[16] data_bar[17] data_bar[18] data_bar[19] data_bar[20] data_bar[21] data_bar[22] data_bar[23] data_bar[24] data_bar[25] data_bar[26] data_bar[27] data_bar[28] data_bar[29] data_bar[30] data_bar[31] mask[0] mask[1] mask[2] mask[3] mask[4] mask[5] mask[6] mask[7] mask[8] mask[9] mask[10] mask[11] mask[12] mask[13] mask[14] mask[15] mask[16] mask[17] mask[18] mask[19] mask[20] mask[21] mask[22] mask[23] mask[24] mask[25] mask[26] mask[27] mask[28] mask[29] mask[30] mask[31] en vdd vdd_write_bl vdd_write_br gnd
Xmod_0 data[0] data_bar[0] mask[0] en bl[0] br[0] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_1 data[1] data_bar[1] mask[1] en bl[1] br[1] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_2 data[2] data_bar[2] mask[2] en bl[2] br[2] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_3 data[3] data_bar[3] mask[3] en bl[3] br[3] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_4 data[4] data_bar[4] mask[4] en bl[4] br[4] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_5 data[5] data_bar[5] mask[5] en bl[5] br[5] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_6 data[6] data_bar[6] mask[6] en bl[6] br[6] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_7 data[7] data_bar[7] mask[7] en bl[7] br[7] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_8 data[8] data_bar[8] mask[8] en bl[8] br[8] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_9 data[9] data_bar[9] mask[9] en bl[9] br[9] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_10 data[10] data_bar[10] mask[10] en bl[10] br[10] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_11 data[11] data_bar[11] mask[11] en bl[11] br[11] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_12 data[12] data_bar[12] mask[12] en bl[12] br[12] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_13 data[13] data_bar[13] mask[13] en bl[13] br[13] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_14 data[14] data_bar[14] mask[14] en bl[14] br[14] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_15 data[15] data_bar[15] mask[15] en bl[15] br[15] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_16 data[16] data_bar[16] mask[16] en bl[16] br[16] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_17 data[17] data_bar[17] mask[17] en bl[17] br[17] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_18 data[18] data_bar[18] mask[18] en bl[18] br[18] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_19 data[19] data_bar[19] mask[19] en bl[19] br[19] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_20 data[20] data_bar[20] mask[20] en bl[20] br[20] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_21 data[21] data_bar[21] mask[21] en bl[21] br[21] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_22 data[22] data_bar[22] mask[22] en bl[22] br[22] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_23 data[23] data_bar[23] mask[23] en bl[23] br[23] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_24 data[24] data_bar[24] mask[24] en bl[24] br[24] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_25 data[25] data_bar[25] mask[25] en bl[25] br[25] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_26 data[26] data_bar[26] mask[26] en bl[26] br[26] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_27 data[27] data_bar[27] mask[27] en bl[27] br[27] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_28 data[28] data_bar[28] mask[28] en bl[28] br[28] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_29 data[29] data_bar[29] mask[29] en bl[29] br[29] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_30 data[30] data_bar[30] mask[30] en bl[30] br[30] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
Xmod_31 data[31] data_bar[31] mask[31] en bl[31] br[31] vdd vdd_write_bl vdd_write_br gnd write_driver_sep_vdd_10
.ENDS write_driver_array

.SUBCKT bitcell_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] vdd gnd
Xbit_r0_c0 bl[0] br[0] wl[0] gnd reram_bitcell_7
Xbit_r1_c0 bl[0] br[0] wl[1] gnd reram_bitcell_7
Xbit_r2_c0 bl[0] br[0] wl[2] gnd reram_bitcell_7
Xbit_r3_c0 bl[0] br[0] wl[3] gnd reram_bitcell_7
Xbit_r4_c0 bl[0] br[0] wl[4] gnd reram_bitcell_7
Xbit_r5_c0 bl[0] br[0] wl[5] gnd reram_bitcell_7
Xbit_r6_c0 bl[0] br[0] wl[6] gnd reram_bitcell_7
Xbit_r7_c0 bl[0] br[0] wl[7] gnd reram_bitcell_7
Xbit_r8_c0 bl[0] br[0] wl[8] gnd reram_bitcell_7
Xbit_r9_c0 bl[0] br[0] wl[9] gnd reram_bitcell_7
Xbit_r10_c0 bl[0] br[0] wl[10] gnd reram_bitcell_7
Xbit_r11_c0 bl[0] br[0] wl[11] gnd reram_bitcell_7
Xbit_r12_c0 bl[0] br[0] wl[12] gnd reram_bitcell_7
Xbit_r13_c0 bl[0] br[0] wl[13] gnd reram_bitcell_7
Xbit_r14_c0 bl[0] br[0] wl[14] gnd reram_bitcell_7
Xbit_r15_c0 bl[0] br[0] wl[15] gnd reram_bitcell_7
Xbit_r16_c0 bl[0] br[0] wl[16] gnd reram_bitcell_7
Xbit_r17_c0 bl[0] br[0] wl[17] gnd reram_bitcell_7
Xbit_r18_c0 bl[0] br[0] wl[18] gnd reram_bitcell_7
Xbit_r19_c0 bl[0] br[0] wl[19] gnd reram_bitcell_7
Xbit_r20_c0 bl[0] br[0] wl[20] gnd reram_bitcell_7
Xbit_r21_c0 bl[0] br[0] wl[21] gnd reram_bitcell_7
Xbit_r22_c0 bl[0] br[0] wl[22] gnd reram_bitcell_7
Xbit_r23_c0 bl[0] br[0] wl[23] gnd reram_bitcell_7
Xbit_r24_c0 bl[0] br[0] wl[24] gnd reram_bitcell_7
Xbit_r25_c0 bl[0] br[0] wl[25] gnd reram_bitcell_7
Xbit_r26_c0 bl[0] br[0] wl[26] gnd reram_bitcell_7
Xbit_r27_c0 bl[0] br[0] wl[27] gnd reram_bitcell_7
Xbit_r28_c0 bl[0] br[0] wl[28] gnd reram_bitcell_7
Xbit_r29_c0 bl[0] br[0] wl[29] gnd reram_bitcell_7
Xbit_r30_c0 bl[0] br[0] wl[30] gnd reram_bitcell_7
Xbit_r31_c0 bl[0] br[0] wl[31] gnd reram_bitcell_7
Xbit_r0_c1 bl[1] br[1] wl[0] gnd reram_bitcell_7
Xbit_r1_c1 bl[1] br[1] wl[1] gnd reram_bitcell_7
Xbit_r2_c1 bl[1] br[1] wl[2] gnd reram_bitcell_7
Xbit_r3_c1 bl[1] br[1] wl[3] gnd reram_bitcell_7
Xbit_r4_c1 bl[1] br[1] wl[4] gnd reram_bitcell_7
Xbit_r5_c1 bl[1] br[1] wl[5] gnd reram_bitcell_7
Xbit_r6_c1 bl[1] br[1] wl[6] gnd reram_bitcell_7
Xbit_r7_c1 bl[1] br[1] wl[7] gnd reram_bitcell_7
Xbit_r8_c1 bl[1] br[1] wl[8] gnd reram_bitcell_7
Xbit_r9_c1 bl[1] br[1] wl[9] gnd reram_bitcell_7
Xbit_r10_c1 bl[1] br[1] wl[10] gnd reram_bitcell_7
Xbit_r11_c1 bl[1] br[1] wl[11] gnd reram_bitcell_7
Xbit_r12_c1 bl[1] br[1] wl[12] gnd reram_bitcell_7
Xbit_r13_c1 bl[1] br[1] wl[13] gnd reram_bitcell_7
Xbit_r14_c1 bl[1] br[1] wl[14] gnd reram_bitcell_7
Xbit_r15_c1 bl[1] br[1] wl[15] gnd reram_bitcell_7
Xbit_r16_c1 bl[1] br[1] wl[16] gnd reram_bitcell_7
Xbit_r17_c1 bl[1] br[1] wl[17] gnd reram_bitcell_7
Xbit_r18_c1 bl[1] br[1] wl[18] gnd reram_bitcell_7
Xbit_r19_c1 bl[1] br[1] wl[19] gnd reram_bitcell_7
Xbit_r20_c1 bl[1] br[1] wl[20] gnd reram_bitcell_7
Xbit_r21_c1 bl[1] br[1] wl[21] gnd reram_bitcell_7
Xbit_r22_c1 bl[1] br[1] wl[22] gnd reram_bitcell_7
Xbit_r23_c1 bl[1] br[1] wl[23] gnd reram_bitcell_7
Xbit_r24_c1 bl[1] br[1] wl[24] gnd reram_bitcell_7
Xbit_r25_c1 bl[1] br[1] wl[25] gnd reram_bitcell_7
Xbit_r26_c1 bl[1] br[1] wl[26] gnd reram_bitcell_7
Xbit_r27_c1 bl[1] br[1] wl[27] gnd reram_bitcell_7
Xbit_r28_c1 bl[1] br[1] wl[28] gnd reram_bitcell_7
Xbit_r29_c1 bl[1] br[1] wl[29] gnd reram_bitcell_7
Xbit_r30_c1 bl[1] br[1] wl[30] gnd reram_bitcell_7
Xbit_r31_c1 bl[1] br[1] wl[31] gnd reram_bitcell_7
Xbit_r0_c2 bl[2] br[2] wl[0] gnd reram_bitcell_7
Xbit_r1_c2 bl[2] br[2] wl[1] gnd reram_bitcell_7
Xbit_r2_c2 bl[2] br[2] wl[2] gnd reram_bitcell_7
Xbit_r3_c2 bl[2] br[2] wl[3] gnd reram_bitcell_7
Xbit_r4_c2 bl[2] br[2] wl[4] gnd reram_bitcell_7
Xbit_r5_c2 bl[2] br[2] wl[5] gnd reram_bitcell_7
Xbit_r6_c2 bl[2] br[2] wl[6] gnd reram_bitcell_7
Xbit_r7_c2 bl[2] br[2] wl[7] gnd reram_bitcell_7
Xbit_r8_c2 bl[2] br[2] wl[8] gnd reram_bitcell_7
Xbit_r9_c2 bl[2] br[2] wl[9] gnd reram_bitcell_7
Xbit_r10_c2 bl[2] br[2] wl[10] gnd reram_bitcell_7
Xbit_r11_c2 bl[2] br[2] wl[11] gnd reram_bitcell_7
Xbit_r12_c2 bl[2] br[2] wl[12] gnd reram_bitcell_7
Xbit_r13_c2 bl[2] br[2] wl[13] gnd reram_bitcell_7
Xbit_r14_c2 bl[2] br[2] wl[14] gnd reram_bitcell_7
Xbit_r15_c2 bl[2] br[2] wl[15] gnd reram_bitcell_7
Xbit_r16_c2 bl[2] br[2] wl[16] gnd reram_bitcell_7
Xbit_r17_c2 bl[2] br[2] wl[17] gnd reram_bitcell_7
Xbit_r18_c2 bl[2] br[2] wl[18] gnd reram_bitcell_7
Xbit_r19_c2 bl[2] br[2] wl[19] gnd reram_bitcell_7
Xbit_r20_c2 bl[2] br[2] wl[20] gnd reram_bitcell_7
Xbit_r21_c2 bl[2] br[2] wl[21] gnd reram_bitcell_7
Xbit_r22_c2 bl[2] br[2] wl[22] gnd reram_bitcell_7
Xbit_r23_c2 bl[2] br[2] wl[23] gnd reram_bitcell_7
Xbit_r24_c2 bl[2] br[2] wl[24] gnd reram_bitcell_7
Xbit_r25_c2 bl[2] br[2] wl[25] gnd reram_bitcell_7
Xbit_r26_c2 bl[2] br[2] wl[26] gnd reram_bitcell_7
Xbit_r27_c2 bl[2] br[2] wl[27] gnd reram_bitcell_7
Xbit_r28_c2 bl[2] br[2] wl[28] gnd reram_bitcell_7
Xbit_r29_c2 bl[2] br[2] wl[29] gnd reram_bitcell_7
Xbit_r30_c2 bl[2] br[2] wl[30] gnd reram_bitcell_7
Xbit_r31_c2 bl[2] br[2] wl[31] gnd reram_bitcell_7
Xbit_r0_c3 bl[3] br[3] wl[0] gnd reram_bitcell_7
Xbit_r1_c3 bl[3] br[3] wl[1] gnd reram_bitcell_7
Xbit_r2_c3 bl[3] br[3] wl[2] gnd reram_bitcell_7
Xbit_r3_c3 bl[3] br[3] wl[3] gnd reram_bitcell_7
Xbit_r4_c3 bl[3] br[3] wl[4] gnd reram_bitcell_7
Xbit_r5_c3 bl[3] br[3] wl[5] gnd reram_bitcell_7
Xbit_r6_c3 bl[3] br[3] wl[6] gnd reram_bitcell_7
Xbit_r7_c3 bl[3] br[3] wl[7] gnd reram_bitcell_7
Xbit_r8_c3 bl[3] br[3] wl[8] gnd reram_bitcell_7
Xbit_r9_c3 bl[3] br[3] wl[9] gnd reram_bitcell_7
Xbit_r10_c3 bl[3] br[3] wl[10] gnd reram_bitcell_7
Xbit_r11_c3 bl[3] br[3] wl[11] gnd reram_bitcell_7
Xbit_r12_c3 bl[3] br[3] wl[12] gnd reram_bitcell_7
Xbit_r13_c3 bl[3] br[3] wl[13] gnd reram_bitcell_7
Xbit_r14_c3 bl[3] br[3] wl[14] gnd reram_bitcell_7
Xbit_r15_c3 bl[3] br[3] wl[15] gnd reram_bitcell_7
Xbit_r16_c3 bl[3] br[3] wl[16] gnd reram_bitcell_7
Xbit_r17_c3 bl[3] br[3] wl[17] gnd reram_bitcell_7
Xbit_r18_c3 bl[3] br[3] wl[18] gnd reram_bitcell_7
Xbit_r19_c3 bl[3] br[3] wl[19] gnd reram_bitcell_7
Xbit_r20_c3 bl[3] br[3] wl[20] gnd reram_bitcell_7
Xbit_r21_c3 bl[3] br[3] wl[21] gnd reram_bitcell_7
Xbit_r22_c3 bl[3] br[3] wl[22] gnd reram_bitcell_7
Xbit_r23_c3 bl[3] br[3] wl[23] gnd reram_bitcell_7
Xbit_r24_c3 bl[3] br[3] wl[24] gnd reram_bitcell_7
Xbit_r25_c3 bl[3] br[3] wl[25] gnd reram_bitcell_7
Xbit_r26_c3 bl[3] br[3] wl[26] gnd reram_bitcell_7
Xbit_r27_c3 bl[3] br[3] wl[27] gnd reram_bitcell_7
Xbit_r28_c3 bl[3] br[3] wl[28] gnd reram_bitcell_7
Xbit_r29_c3 bl[3] br[3] wl[29] gnd reram_bitcell_7
Xbit_r30_c3 bl[3] br[3] wl[30] gnd reram_bitcell_7
Xbit_r31_c3 bl[3] br[3] wl[31] gnd reram_bitcell_7
Xbit_r0_c4 bl[4] br[4] wl[0] gnd reram_bitcell_7
Xbit_r1_c4 bl[4] br[4] wl[1] gnd reram_bitcell_7
Xbit_r2_c4 bl[4] br[4] wl[2] gnd reram_bitcell_7
Xbit_r3_c4 bl[4] br[4] wl[3] gnd reram_bitcell_7
Xbit_r4_c4 bl[4] br[4] wl[4] gnd reram_bitcell_7
Xbit_r5_c4 bl[4] br[4] wl[5] gnd reram_bitcell_7
Xbit_r6_c4 bl[4] br[4] wl[6] gnd reram_bitcell_7
Xbit_r7_c4 bl[4] br[4] wl[7] gnd reram_bitcell_7
Xbit_r8_c4 bl[4] br[4] wl[8] gnd reram_bitcell_7
Xbit_r9_c4 bl[4] br[4] wl[9] gnd reram_bitcell_7
Xbit_r10_c4 bl[4] br[4] wl[10] gnd reram_bitcell_7
Xbit_r11_c4 bl[4] br[4] wl[11] gnd reram_bitcell_7
Xbit_r12_c4 bl[4] br[4] wl[12] gnd reram_bitcell_7
Xbit_r13_c4 bl[4] br[4] wl[13] gnd reram_bitcell_7
Xbit_r14_c4 bl[4] br[4] wl[14] gnd reram_bitcell_7
Xbit_r15_c4 bl[4] br[4] wl[15] gnd reram_bitcell_7
Xbit_r16_c4 bl[4] br[4] wl[16] gnd reram_bitcell_7
Xbit_r17_c4 bl[4] br[4] wl[17] gnd reram_bitcell_7
Xbit_r18_c4 bl[4] br[4] wl[18] gnd reram_bitcell_7
Xbit_r19_c4 bl[4] br[4] wl[19] gnd reram_bitcell_7
Xbit_r20_c4 bl[4] br[4] wl[20] gnd reram_bitcell_7
Xbit_r21_c4 bl[4] br[4] wl[21] gnd reram_bitcell_7
Xbit_r22_c4 bl[4] br[4] wl[22] gnd reram_bitcell_7
Xbit_r23_c4 bl[4] br[4] wl[23] gnd reram_bitcell_7
Xbit_r24_c4 bl[4] br[4] wl[24] gnd reram_bitcell_7
Xbit_r25_c4 bl[4] br[4] wl[25] gnd reram_bitcell_7
Xbit_r26_c4 bl[4] br[4] wl[26] gnd reram_bitcell_7
Xbit_r27_c4 bl[4] br[4] wl[27] gnd reram_bitcell_7
Xbit_r28_c4 bl[4] br[4] wl[28] gnd reram_bitcell_7
Xbit_r29_c4 bl[4] br[4] wl[29] gnd reram_bitcell_7
Xbit_r30_c4 bl[4] br[4] wl[30] gnd reram_bitcell_7
Xbit_r31_c4 bl[4] br[4] wl[31] gnd reram_bitcell_7
Xbit_r0_c5 bl[5] br[5] wl[0] gnd reram_bitcell_7
Xbit_r1_c5 bl[5] br[5] wl[1] gnd reram_bitcell_7
Xbit_r2_c5 bl[5] br[5] wl[2] gnd reram_bitcell_7
Xbit_r3_c5 bl[5] br[5] wl[3] gnd reram_bitcell_7
Xbit_r4_c5 bl[5] br[5] wl[4] gnd reram_bitcell_7
Xbit_r5_c5 bl[5] br[5] wl[5] gnd reram_bitcell_7
Xbit_r6_c5 bl[5] br[5] wl[6] gnd reram_bitcell_7
Xbit_r7_c5 bl[5] br[5] wl[7] gnd reram_bitcell_7
Xbit_r8_c5 bl[5] br[5] wl[8] gnd reram_bitcell_7
Xbit_r9_c5 bl[5] br[5] wl[9] gnd reram_bitcell_7
Xbit_r10_c5 bl[5] br[5] wl[10] gnd reram_bitcell_7
Xbit_r11_c5 bl[5] br[5] wl[11] gnd reram_bitcell_7
Xbit_r12_c5 bl[5] br[5] wl[12] gnd reram_bitcell_7
Xbit_r13_c5 bl[5] br[5] wl[13] gnd reram_bitcell_7
Xbit_r14_c5 bl[5] br[5] wl[14] gnd reram_bitcell_7
Xbit_r15_c5 bl[5] br[5] wl[15] gnd reram_bitcell_7
Xbit_r16_c5 bl[5] br[5] wl[16] gnd reram_bitcell_7
Xbit_r17_c5 bl[5] br[5] wl[17] gnd reram_bitcell_7
Xbit_r18_c5 bl[5] br[5] wl[18] gnd reram_bitcell_7
Xbit_r19_c5 bl[5] br[5] wl[19] gnd reram_bitcell_7
Xbit_r20_c5 bl[5] br[5] wl[20] gnd reram_bitcell_7
Xbit_r21_c5 bl[5] br[5] wl[21] gnd reram_bitcell_7
Xbit_r22_c5 bl[5] br[5] wl[22] gnd reram_bitcell_7
Xbit_r23_c5 bl[5] br[5] wl[23] gnd reram_bitcell_7
Xbit_r24_c5 bl[5] br[5] wl[24] gnd reram_bitcell_7
Xbit_r25_c5 bl[5] br[5] wl[25] gnd reram_bitcell_7
Xbit_r26_c5 bl[5] br[5] wl[26] gnd reram_bitcell_7
Xbit_r27_c5 bl[5] br[5] wl[27] gnd reram_bitcell_7
Xbit_r28_c5 bl[5] br[5] wl[28] gnd reram_bitcell_7
Xbit_r29_c5 bl[5] br[5] wl[29] gnd reram_bitcell_7
Xbit_r30_c5 bl[5] br[5] wl[30] gnd reram_bitcell_7
Xbit_r31_c5 bl[5] br[5] wl[31] gnd reram_bitcell_7
Xbit_r0_c6 bl[6] br[6] wl[0] gnd reram_bitcell_7
Xbit_r1_c6 bl[6] br[6] wl[1] gnd reram_bitcell_7
Xbit_r2_c6 bl[6] br[6] wl[2] gnd reram_bitcell_7
Xbit_r3_c6 bl[6] br[6] wl[3] gnd reram_bitcell_7
Xbit_r4_c6 bl[6] br[6] wl[4] gnd reram_bitcell_7
Xbit_r5_c6 bl[6] br[6] wl[5] gnd reram_bitcell_7
Xbit_r6_c6 bl[6] br[6] wl[6] gnd reram_bitcell_7
Xbit_r7_c6 bl[6] br[6] wl[7] gnd reram_bitcell_7
Xbit_r8_c6 bl[6] br[6] wl[8] gnd reram_bitcell_7
Xbit_r9_c6 bl[6] br[6] wl[9] gnd reram_bitcell_7
Xbit_r10_c6 bl[6] br[6] wl[10] gnd reram_bitcell_7
Xbit_r11_c6 bl[6] br[6] wl[11] gnd reram_bitcell_7
Xbit_r12_c6 bl[6] br[6] wl[12] gnd reram_bitcell_7
Xbit_r13_c6 bl[6] br[6] wl[13] gnd reram_bitcell_7
Xbit_r14_c6 bl[6] br[6] wl[14] gnd reram_bitcell_7
Xbit_r15_c6 bl[6] br[6] wl[15] gnd reram_bitcell_7
Xbit_r16_c6 bl[6] br[6] wl[16] gnd reram_bitcell_7
Xbit_r17_c6 bl[6] br[6] wl[17] gnd reram_bitcell_7
Xbit_r18_c6 bl[6] br[6] wl[18] gnd reram_bitcell_7
Xbit_r19_c6 bl[6] br[6] wl[19] gnd reram_bitcell_7
Xbit_r20_c6 bl[6] br[6] wl[20] gnd reram_bitcell_7
Xbit_r21_c6 bl[6] br[6] wl[21] gnd reram_bitcell_7
Xbit_r22_c6 bl[6] br[6] wl[22] gnd reram_bitcell_7
Xbit_r23_c6 bl[6] br[6] wl[23] gnd reram_bitcell_7
Xbit_r24_c6 bl[6] br[6] wl[24] gnd reram_bitcell_7
Xbit_r25_c6 bl[6] br[6] wl[25] gnd reram_bitcell_7
Xbit_r26_c6 bl[6] br[6] wl[26] gnd reram_bitcell_7
Xbit_r27_c6 bl[6] br[6] wl[27] gnd reram_bitcell_7
Xbit_r28_c6 bl[6] br[6] wl[28] gnd reram_bitcell_7
Xbit_r29_c6 bl[6] br[6] wl[29] gnd reram_bitcell_7
Xbit_r30_c6 bl[6] br[6] wl[30] gnd reram_bitcell_7
Xbit_r31_c6 bl[6] br[6] wl[31] gnd reram_bitcell_7
Xbit_r0_c7 bl[7] br[7] wl[0] gnd reram_bitcell_7
Xbit_r1_c7 bl[7] br[7] wl[1] gnd reram_bitcell_7
Xbit_r2_c7 bl[7] br[7] wl[2] gnd reram_bitcell_7
Xbit_r3_c7 bl[7] br[7] wl[3] gnd reram_bitcell_7
Xbit_r4_c7 bl[7] br[7] wl[4] gnd reram_bitcell_7
Xbit_r5_c7 bl[7] br[7] wl[5] gnd reram_bitcell_7
Xbit_r6_c7 bl[7] br[7] wl[6] gnd reram_bitcell_7
Xbit_r7_c7 bl[7] br[7] wl[7] gnd reram_bitcell_7
Xbit_r8_c7 bl[7] br[7] wl[8] gnd reram_bitcell_7
Xbit_r9_c7 bl[7] br[7] wl[9] gnd reram_bitcell_7
Xbit_r10_c7 bl[7] br[7] wl[10] gnd reram_bitcell_7
Xbit_r11_c7 bl[7] br[7] wl[11] gnd reram_bitcell_7
Xbit_r12_c7 bl[7] br[7] wl[12] gnd reram_bitcell_7
Xbit_r13_c7 bl[7] br[7] wl[13] gnd reram_bitcell_7
Xbit_r14_c7 bl[7] br[7] wl[14] gnd reram_bitcell_7
Xbit_r15_c7 bl[7] br[7] wl[15] gnd reram_bitcell_7
Xbit_r16_c7 bl[7] br[7] wl[16] gnd reram_bitcell_7
Xbit_r17_c7 bl[7] br[7] wl[17] gnd reram_bitcell_7
Xbit_r18_c7 bl[7] br[7] wl[18] gnd reram_bitcell_7
Xbit_r19_c7 bl[7] br[7] wl[19] gnd reram_bitcell_7
Xbit_r20_c7 bl[7] br[7] wl[20] gnd reram_bitcell_7
Xbit_r21_c7 bl[7] br[7] wl[21] gnd reram_bitcell_7
Xbit_r22_c7 bl[7] br[7] wl[22] gnd reram_bitcell_7
Xbit_r23_c7 bl[7] br[7] wl[23] gnd reram_bitcell_7
Xbit_r24_c7 bl[7] br[7] wl[24] gnd reram_bitcell_7
Xbit_r25_c7 bl[7] br[7] wl[25] gnd reram_bitcell_7
Xbit_r26_c7 bl[7] br[7] wl[26] gnd reram_bitcell_7
Xbit_r27_c7 bl[7] br[7] wl[27] gnd reram_bitcell_7
Xbit_r28_c7 bl[7] br[7] wl[28] gnd reram_bitcell_7
Xbit_r29_c7 bl[7] br[7] wl[29] gnd reram_bitcell_7
Xbit_r30_c7 bl[7] br[7] wl[30] gnd reram_bitcell_7
Xbit_r31_c7 bl[7] br[7] wl[31] gnd reram_bitcell_7
Xbit_r0_c8 bl[8] br[8] wl[0] gnd reram_bitcell_7
Xbit_r1_c8 bl[8] br[8] wl[1] gnd reram_bitcell_7
Xbit_r2_c8 bl[8] br[8] wl[2] gnd reram_bitcell_7
Xbit_r3_c8 bl[8] br[8] wl[3] gnd reram_bitcell_7
Xbit_r4_c8 bl[8] br[8] wl[4] gnd reram_bitcell_7
Xbit_r5_c8 bl[8] br[8] wl[5] gnd reram_bitcell_7
Xbit_r6_c8 bl[8] br[8] wl[6] gnd reram_bitcell_7
Xbit_r7_c8 bl[8] br[8] wl[7] gnd reram_bitcell_7
Xbit_r8_c8 bl[8] br[8] wl[8] gnd reram_bitcell_7
Xbit_r9_c8 bl[8] br[8] wl[9] gnd reram_bitcell_7
Xbit_r10_c8 bl[8] br[8] wl[10] gnd reram_bitcell_7
Xbit_r11_c8 bl[8] br[8] wl[11] gnd reram_bitcell_7
Xbit_r12_c8 bl[8] br[8] wl[12] gnd reram_bitcell_7
Xbit_r13_c8 bl[8] br[8] wl[13] gnd reram_bitcell_7
Xbit_r14_c8 bl[8] br[8] wl[14] gnd reram_bitcell_7
Xbit_r15_c8 bl[8] br[8] wl[15] gnd reram_bitcell_7
Xbit_r16_c8 bl[8] br[8] wl[16] gnd reram_bitcell_7
Xbit_r17_c8 bl[8] br[8] wl[17] gnd reram_bitcell_7
Xbit_r18_c8 bl[8] br[8] wl[18] gnd reram_bitcell_7
Xbit_r19_c8 bl[8] br[8] wl[19] gnd reram_bitcell_7
Xbit_r20_c8 bl[8] br[8] wl[20] gnd reram_bitcell_7
Xbit_r21_c8 bl[8] br[8] wl[21] gnd reram_bitcell_7
Xbit_r22_c8 bl[8] br[8] wl[22] gnd reram_bitcell_7
Xbit_r23_c8 bl[8] br[8] wl[23] gnd reram_bitcell_7
Xbit_r24_c8 bl[8] br[8] wl[24] gnd reram_bitcell_7
Xbit_r25_c8 bl[8] br[8] wl[25] gnd reram_bitcell_7
Xbit_r26_c8 bl[8] br[8] wl[26] gnd reram_bitcell_7
Xbit_r27_c8 bl[8] br[8] wl[27] gnd reram_bitcell_7
Xbit_r28_c8 bl[8] br[8] wl[28] gnd reram_bitcell_7
Xbit_r29_c8 bl[8] br[8] wl[29] gnd reram_bitcell_7
Xbit_r30_c8 bl[8] br[8] wl[30] gnd reram_bitcell_7
Xbit_r31_c8 bl[8] br[8] wl[31] gnd reram_bitcell_7
Xbit_r0_c9 bl[9] br[9] wl[0] gnd reram_bitcell_7
Xbit_r1_c9 bl[9] br[9] wl[1] gnd reram_bitcell_7
Xbit_r2_c9 bl[9] br[9] wl[2] gnd reram_bitcell_7
Xbit_r3_c9 bl[9] br[9] wl[3] gnd reram_bitcell_7
Xbit_r4_c9 bl[9] br[9] wl[4] gnd reram_bitcell_7
Xbit_r5_c9 bl[9] br[9] wl[5] gnd reram_bitcell_7
Xbit_r6_c9 bl[9] br[9] wl[6] gnd reram_bitcell_7
Xbit_r7_c9 bl[9] br[9] wl[7] gnd reram_bitcell_7
Xbit_r8_c9 bl[9] br[9] wl[8] gnd reram_bitcell_7
Xbit_r9_c9 bl[9] br[9] wl[9] gnd reram_bitcell_7
Xbit_r10_c9 bl[9] br[9] wl[10] gnd reram_bitcell_7
Xbit_r11_c9 bl[9] br[9] wl[11] gnd reram_bitcell_7
Xbit_r12_c9 bl[9] br[9] wl[12] gnd reram_bitcell_7
Xbit_r13_c9 bl[9] br[9] wl[13] gnd reram_bitcell_7
Xbit_r14_c9 bl[9] br[9] wl[14] gnd reram_bitcell_7
Xbit_r15_c9 bl[9] br[9] wl[15] gnd reram_bitcell_7
Xbit_r16_c9 bl[9] br[9] wl[16] gnd reram_bitcell_7
Xbit_r17_c9 bl[9] br[9] wl[17] gnd reram_bitcell_7
Xbit_r18_c9 bl[9] br[9] wl[18] gnd reram_bitcell_7
Xbit_r19_c9 bl[9] br[9] wl[19] gnd reram_bitcell_7
Xbit_r20_c9 bl[9] br[9] wl[20] gnd reram_bitcell_7
Xbit_r21_c9 bl[9] br[9] wl[21] gnd reram_bitcell_7
Xbit_r22_c9 bl[9] br[9] wl[22] gnd reram_bitcell_7
Xbit_r23_c9 bl[9] br[9] wl[23] gnd reram_bitcell_7
Xbit_r24_c9 bl[9] br[9] wl[24] gnd reram_bitcell_7
Xbit_r25_c9 bl[9] br[9] wl[25] gnd reram_bitcell_7
Xbit_r26_c9 bl[9] br[9] wl[26] gnd reram_bitcell_7
Xbit_r27_c9 bl[9] br[9] wl[27] gnd reram_bitcell_7
Xbit_r28_c9 bl[9] br[9] wl[28] gnd reram_bitcell_7
Xbit_r29_c9 bl[9] br[9] wl[29] gnd reram_bitcell_7
Xbit_r30_c9 bl[9] br[9] wl[30] gnd reram_bitcell_7
Xbit_r31_c9 bl[9] br[9] wl[31] gnd reram_bitcell_7
Xbit_r0_c10 bl[10] br[10] wl[0] gnd reram_bitcell_7
Xbit_r1_c10 bl[10] br[10] wl[1] gnd reram_bitcell_7
Xbit_r2_c10 bl[10] br[10] wl[2] gnd reram_bitcell_7
Xbit_r3_c10 bl[10] br[10] wl[3] gnd reram_bitcell_7
Xbit_r4_c10 bl[10] br[10] wl[4] gnd reram_bitcell_7
Xbit_r5_c10 bl[10] br[10] wl[5] gnd reram_bitcell_7
Xbit_r6_c10 bl[10] br[10] wl[6] gnd reram_bitcell_7
Xbit_r7_c10 bl[10] br[10] wl[7] gnd reram_bitcell_7
Xbit_r8_c10 bl[10] br[10] wl[8] gnd reram_bitcell_7
Xbit_r9_c10 bl[10] br[10] wl[9] gnd reram_bitcell_7
Xbit_r10_c10 bl[10] br[10] wl[10] gnd reram_bitcell_7
Xbit_r11_c10 bl[10] br[10] wl[11] gnd reram_bitcell_7
Xbit_r12_c10 bl[10] br[10] wl[12] gnd reram_bitcell_7
Xbit_r13_c10 bl[10] br[10] wl[13] gnd reram_bitcell_7
Xbit_r14_c10 bl[10] br[10] wl[14] gnd reram_bitcell_7
Xbit_r15_c10 bl[10] br[10] wl[15] gnd reram_bitcell_7
Xbit_r16_c10 bl[10] br[10] wl[16] gnd reram_bitcell_7
Xbit_r17_c10 bl[10] br[10] wl[17] gnd reram_bitcell_7
Xbit_r18_c10 bl[10] br[10] wl[18] gnd reram_bitcell_7
Xbit_r19_c10 bl[10] br[10] wl[19] gnd reram_bitcell_7
Xbit_r20_c10 bl[10] br[10] wl[20] gnd reram_bitcell_7
Xbit_r21_c10 bl[10] br[10] wl[21] gnd reram_bitcell_7
Xbit_r22_c10 bl[10] br[10] wl[22] gnd reram_bitcell_7
Xbit_r23_c10 bl[10] br[10] wl[23] gnd reram_bitcell_7
Xbit_r24_c10 bl[10] br[10] wl[24] gnd reram_bitcell_7
Xbit_r25_c10 bl[10] br[10] wl[25] gnd reram_bitcell_7
Xbit_r26_c10 bl[10] br[10] wl[26] gnd reram_bitcell_7
Xbit_r27_c10 bl[10] br[10] wl[27] gnd reram_bitcell_7
Xbit_r28_c10 bl[10] br[10] wl[28] gnd reram_bitcell_7
Xbit_r29_c10 bl[10] br[10] wl[29] gnd reram_bitcell_7
Xbit_r30_c10 bl[10] br[10] wl[30] gnd reram_bitcell_7
Xbit_r31_c10 bl[10] br[10] wl[31] gnd reram_bitcell_7
Xbit_r0_c11 bl[11] br[11] wl[0] gnd reram_bitcell_7
Xbit_r1_c11 bl[11] br[11] wl[1] gnd reram_bitcell_7
Xbit_r2_c11 bl[11] br[11] wl[2] gnd reram_bitcell_7
Xbit_r3_c11 bl[11] br[11] wl[3] gnd reram_bitcell_7
Xbit_r4_c11 bl[11] br[11] wl[4] gnd reram_bitcell_7
Xbit_r5_c11 bl[11] br[11] wl[5] gnd reram_bitcell_7
Xbit_r6_c11 bl[11] br[11] wl[6] gnd reram_bitcell_7
Xbit_r7_c11 bl[11] br[11] wl[7] gnd reram_bitcell_7
Xbit_r8_c11 bl[11] br[11] wl[8] gnd reram_bitcell_7
Xbit_r9_c11 bl[11] br[11] wl[9] gnd reram_bitcell_7
Xbit_r10_c11 bl[11] br[11] wl[10] gnd reram_bitcell_7
Xbit_r11_c11 bl[11] br[11] wl[11] gnd reram_bitcell_7
Xbit_r12_c11 bl[11] br[11] wl[12] gnd reram_bitcell_7
Xbit_r13_c11 bl[11] br[11] wl[13] gnd reram_bitcell_7
Xbit_r14_c11 bl[11] br[11] wl[14] gnd reram_bitcell_7
Xbit_r15_c11 bl[11] br[11] wl[15] gnd reram_bitcell_7
Xbit_r16_c11 bl[11] br[11] wl[16] gnd reram_bitcell_7
Xbit_r17_c11 bl[11] br[11] wl[17] gnd reram_bitcell_7
Xbit_r18_c11 bl[11] br[11] wl[18] gnd reram_bitcell_7
Xbit_r19_c11 bl[11] br[11] wl[19] gnd reram_bitcell_7
Xbit_r20_c11 bl[11] br[11] wl[20] gnd reram_bitcell_7
Xbit_r21_c11 bl[11] br[11] wl[21] gnd reram_bitcell_7
Xbit_r22_c11 bl[11] br[11] wl[22] gnd reram_bitcell_7
Xbit_r23_c11 bl[11] br[11] wl[23] gnd reram_bitcell_7
Xbit_r24_c11 bl[11] br[11] wl[24] gnd reram_bitcell_7
Xbit_r25_c11 bl[11] br[11] wl[25] gnd reram_bitcell_7
Xbit_r26_c11 bl[11] br[11] wl[26] gnd reram_bitcell_7
Xbit_r27_c11 bl[11] br[11] wl[27] gnd reram_bitcell_7
Xbit_r28_c11 bl[11] br[11] wl[28] gnd reram_bitcell_7
Xbit_r29_c11 bl[11] br[11] wl[29] gnd reram_bitcell_7
Xbit_r30_c11 bl[11] br[11] wl[30] gnd reram_bitcell_7
Xbit_r31_c11 bl[11] br[11] wl[31] gnd reram_bitcell_7
Xbit_r0_c12 bl[12] br[12] wl[0] gnd reram_bitcell_7
Xbit_r1_c12 bl[12] br[12] wl[1] gnd reram_bitcell_7
Xbit_r2_c12 bl[12] br[12] wl[2] gnd reram_bitcell_7
Xbit_r3_c12 bl[12] br[12] wl[3] gnd reram_bitcell_7
Xbit_r4_c12 bl[12] br[12] wl[4] gnd reram_bitcell_7
Xbit_r5_c12 bl[12] br[12] wl[5] gnd reram_bitcell_7
Xbit_r6_c12 bl[12] br[12] wl[6] gnd reram_bitcell_7
Xbit_r7_c12 bl[12] br[12] wl[7] gnd reram_bitcell_7
Xbit_r8_c12 bl[12] br[12] wl[8] gnd reram_bitcell_7
Xbit_r9_c12 bl[12] br[12] wl[9] gnd reram_bitcell_7
Xbit_r10_c12 bl[12] br[12] wl[10] gnd reram_bitcell_7
Xbit_r11_c12 bl[12] br[12] wl[11] gnd reram_bitcell_7
Xbit_r12_c12 bl[12] br[12] wl[12] gnd reram_bitcell_7
Xbit_r13_c12 bl[12] br[12] wl[13] gnd reram_bitcell_7
Xbit_r14_c12 bl[12] br[12] wl[14] gnd reram_bitcell_7
Xbit_r15_c12 bl[12] br[12] wl[15] gnd reram_bitcell_7
Xbit_r16_c12 bl[12] br[12] wl[16] gnd reram_bitcell_7
Xbit_r17_c12 bl[12] br[12] wl[17] gnd reram_bitcell_7
Xbit_r18_c12 bl[12] br[12] wl[18] gnd reram_bitcell_7
Xbit_r19_c12 bl[12] br[12] wl[19] gnd reram_bitcell_7
Xbit_r20_c12 bl[12] br[12] wl[20] gnd reram_bitcell_7
Xbit_r21_c12 bl[12] br[12] wl[21] gnd reram_bitcell_7
Xbit_r22_c12 bl[12] br[12] wl[22] gnd reram_bitcell_7
Xbit_r23_c12 bl[12] br[12] wl[23] gnd reram_bitcell_7
Xbit_r24_c12 bl[12] br[12] wl[24] gnd reram_bitcell_7
Xbit_r25_c12 bl[12] br[12] wl[25] gnd reram_bitcell_7
Xbit_r26_c12 bl[12] br[12] wl[26] gnd reram_bitcell_7
Xbit_r27_c12 bl[12] br[12] wl[27] gnd reram_bitcell_7
Xbit_r28_c12 bl[12] br[12] wl[28] gnd reram_bitcell_7
Xbit_r29_c12 bl[12] br[12] wl[29] gnd reram_bitcell_7
Xbit_r30_c12 bl[12] br[12] wl[30] gnd reram_bitcell_7
Xbit_r31_c12 bl[12] br[12] wl[31] gnd reram_bitcell_7
Xbit_r0_c13 bl[13] br[13] wl[0] gnd reram_bitcell_7
Xbit_r1_c13 bl[13] br[13] wl[1] gnd reram_bitcell_7
Xbit_r2_c13 bl[13] br[13] wl[2] gnd reram_bitcell_7
Xbit_r3_c13 bl[13] br[13] wl[3] gnd reram_bitcell_7
Xbit_r4_c13 bl[13] br[13] wl[4] gnd reram_bitcell_7
Xbit_r5_c13 bl[13] br[13] wl[5] gnd reram_bitcell_7
Xbit_r6_c13 bl[13] br[13] wl[6] gnd reram_bitcell_7
Xbit_r7_c13 bl[13] br[13] wl[7] gnd reram_bitcell_7
Xbit_r8_c13 bl[13] br[13] wl[8] gnd reram_bitcell_7
Xbit_r9_c13 bl[13] br[13] wl[9] gnd reram_bitcell_7
Xbit_r10_c13 bl[13] br[13] wl[10] gnd reram_bitcell_7
Xbit_r11_c13 bl[13] br[13] wl[11] gnd reram_bitcell_7
Xbit_r12_c13 bl[13] br[13] wl[12] gnd reram_bitcell_7
Xbit_r13_c13 bl[13] br[13] wl[13] gnd reram_bitcell_7
Xbit_r14_c13 bl[13] br[13] wl[14] gnd reram_bitcell_7
Xbit_r15_c13 bl[13] br[13] wl[15] gnd reram_bitcell_7
Xbit_r16_c13 bl[13] br[13] wl[16] gnd reram_bitcell_7
Xbit_r17_c13 bl[13] br[13] wl[17] gnd reram_bitcell_7
Xbit_r18_c13 bl[13] br[13] wl[18] gnd reram_bitcell_7
Xbit_r19_c13 bl[13] br[13] wl[19] gnd reram_bitcell_7
Xbit_r20_c13 bl[13] br[13] wl[20] gnd reram_bitcell_7
Xbit_r21_c13 bl[13] br[13] wl[21] gnd reram_bitcell_7
Xbit_r22_c13 bl[13] br[13] wl[22] gnd reram_bitcell_7
Xbit_r23_c13 bl[13] br[13] wl[23] gnd reram_bitcell_7
Xbit_r24_c13 bl[13] br[13] wl[24] gnd reram_bitcell_7
Xbit_r25_c13 bl[13] br[13] wl[25] gnd reram_bitcell_7
Xbit_r26_c13 bl[13] br[13] wl[26] gnd reram_bitcell_7
Xbit_r27_c13 bl[13] br[13] wl[27] gnd reram_bitcell_7
Xbit_r28_c13 bl[13] br[13] wl[28] gnd reram_bitcell_7
Xbit_r29_c13 bl[13] br[13] wl[29] gnd reram_bitcell_7
Xbit_r30_c13 bl[13] br[13] wl[30] gnd reram_bitcell_7
Xbit_r31_c13 bl[13] br[13] wl[31] gnd reram_bitcell_7
Xbit_r0_c14 bl[14] br[14] wl[0] gnd reram_bitcell_7
Xbit_r1_c14 bl[14] br[14] wl[1] gnd reram_bitcell_7
Xbit_r2_c14 bl[14] br[14] wl[2] gnd reram_bitcell_7
Xbit_r3_c14 bl[14] br[14] wl[3] gnd reram_bitcell_7
Xbit_r4_c14 bl[14] br[14] wl[4] gnd reram_bitcell_7
Xbit_r5_c14 bl[14] br[14] wl[5] gnd reram_bitcell_7
Xbit_r6_c14 bl[14] br[14] wl[6] gnd reram_bitcell_7
Xbit_r7_c14 bl[14] br[14] wl[7] gnd reram_bitcell_7
Xbit_r8_c14 bl[14] br[14] wl[8] gnd reram_bitcell_7
Xbit_r9_c14 bl[14] br[14] wl[9] gnd reram_bitcell_7
Xbit_r10_c14 bl[14] br[14] wl[10] gnd reram_bitcell_7
Xbit_r11_c14 bl[14] br[14] wl[11] gnd reram_bitcell_7
Xbit_r12_c14 bl[14] br[14] wl[12] gnd reram_bitcell_7
Xbit_r13_c14 bl[14] br[14] wl[13] gnd reram_bitcell_7
Xbit_r14_c14 bl[14] br[14] wl[14] gnd reram_bitcell_7
Xbit_r15_c14 bl[14] br[14] wl[15] gnd reram_bitcell_7
Xbit_r16_c14 bl[14] br[14] wl[16] gnd reram_bitcell_7
Xbit_r17_c14 bl[14] br[14] wl[17] gnd reram_bitcell_7
Xbit_r18_c14 bl[14] br[14] wl[18] gnd reram_bitcell_7
Xbit_r19_c14 bl[14] br[14] wl[19] gnd reram_bitcell_7
Xbit_r20_c14 bl[14] br[14] wl[20] gnd reram_bitcell_7
Xbit_r21_c14 bl[14] br[14] wl[21] gnd reram_bitcell_7
Xbit_r22_c14 bl[14] br[14] wl[22] gnd reram_bitcell_7
Xbit_r23_c14 bl[14] br[14] wl[23] gnd reram_bitcell_7
Xbit_r24_c14 bl[14] br[14] wl[24] gnd reram_bitcell_7
Xbit_r25_c14 bl[14] br[14] wl[25] gnd reram_bitcell_7
Xbit_r26_c14 bl[14] br[14] wl[26] gnd reram_bitcell_7
Xbit_r27_c14 bl[14] br[14] wl[27] gnd reram_bitcell_7
Xbit_r28_c14 bl[14] br[14] wl[28] gnd reram_bitcell_7
Xbit_r29_c14 bl[14] br[14] wl[29] gnd reram_bitcell_7
Xbit_r30_c14 bl[14] br[14] wl[30] gnd reram_bitcell_7
Xbit_r31_c14 bl[14] br[14] wl[31] gnd reram_bitcell_7
Xbit_r0_c15 bl[15] br[15] wl[0] gnd reram_bitcell_7
Xbit_r1_c15 bl[15] br[15] wl[1] gnd reram_bitcell_7
Xbit_r2_c15 bl[15] br[15] wl[2] gnd reram_bitcell_7
Xbit_r3_c15 bl[15] br[15] wl[3] gnd reram_bitcell_7
Xbit_r4_c15 bl[15] br[15] wl[4] gnd reram_bitcell_7
Xbit_r5_c15 bl[15] br[15] wl[5] gnd reram_bitcell_7
Xbit_r6_c15 bl[15] br[15] wl[6] gnd reram_bitcell_7
Xbit_r7_c15 bl[15] br[15] wl[7] gnd reram_bitcell_7
Xbit_r8_c15 bl[15] br[15] wl[8] gnd reram_bitcell_7
Xbit_r9_c15 bl[15] br[15] wl[9] gnd reram_bitcell_7
Xbit_r10_c15 bl[15] br[15] wl[10] gnd reram_bitcell_7
Xbit_r11_c15 bl[15] br[15] wl[11] gnd reram_bitcell_7
Xbit_r12_c15 bl[15] br[15] wl[12] gnd reram_bitcell_7
Xbit_r13_c15 bl[15] br[15] wl[13] gnd reram_bitcell_7
Xbit_r14_c15 bl[15] br[15] wl[14] gnd reram_bitcell_7
Xbit_r15_c15 bl[15] br[15] wl[15] gnd reram_bitcell_7
Xbit_r16_c15 bl[15] br[15] wl[16] gnd reram_bitcell_7
Xbit_r17_c15 bl[15] br[15] wl[17] gnd reram_bitcell_7
Xbit_r18_c15 bl[15] br[15] wl[18] gnd reram_bitcell_7
Xbit_r19_c15 bl[15] br[15] wl[19] gnd reram_bitcell_7
Xbit_r20_c15 bl[15] br[15] wl[20] gnd reram_bitcell_7
Xbit_r21_c15 bl[15] br[15] wl[21] gnd reram_bitcell_7
Xbit_r22_c15 bl[15] br[15] wl[22] gnd reram_bitcell_7
Xbit_r23_c15 bl[15] br[15] wl[23] gnd reram_bitcell_7
Xbit_r24_c15 bl[15] br[15] wl[24] gnd reram_bitcell_7
Xbit_r25_c15 bl[15] br[15] wl[25] gnd reram_bitcell_7
Xbit_r26_c15 bl[15] br[15] wl[26] gnd reram_bitcell_7
Xbit_r27_c15 bl[15] br[15] wl[27] gnd reram_bitcell_7
Xbit_r28_c15 bl[15] br[15] wl[28] gnd reram_bitcell_7
Xbit_r29_c15 bl[15] br[15] wl[29] gnd reram_bitcell_7
Xbit_r30_c15 bl[15] br[15] wl[30] gnd reram_bitcell_7
Xbit_r31_c15 bl[15] br[15] wl[31] gnd reram_bitcell_7
Xbit_r0_c16 bl[16] br[16] wl[0] gnd reram_bitcell_7
Xbit_r1_c16 bl[16] br[16] wl[1] gnd reram_bitcell_7
Xbit_r2_c16 bl[16] br[16] wl[2] gnd reram_bitcell_7
Xbit_r3_c16 bl[16] br[16] wl[3] gnd reram_bitcell_7
Xbit_r4_c16 bl[16] br[16] wl[4] gnd reram_bitcell_7
Xbit_r5_c16 bl[16] br[16] wl[5] gnd reram_bitcell_7
Xbit_r6_c16 bl[16] br[16] wl[6] gnd reram_bitcell_7
Xbit_r7_c16 bl[16] br[16] wl[7] gnd reram_bitcell_7
Xbit_r8_c16 bl[16] br[16] wl[8] gnd reram_bitcell_7
Xbit_r9_c16 bl[16] br[16] wl[9] gnd reram_bitcell_7
Xbit_r10_c16 bl[16] br[16] wl[10] gnd reram_bitcell_7
Xbit_r11_c16 bl[16] br[16] wl[11] gnd reram_bitcell_7
Xbit_r12_c16 bl[16] br[16] wl[12] gnd reram_bitcell_7
Xbit_r13_c16 bl[16] br[16] wl[13] gnd reram_bitcell_7
Xbit_r14_c16 bl[16] br[16] wl[14] gnd reram_bitcell_7
Xbit_r15_c16 bl[16] br[16] wl[15] gnd reram_bitcell_7
Xbit_r16_c16 bl[16] br[16] wl[16] gnd reram_bitcell_7
Xbit_r17_c16 bl[16] br[16] wl[17] gnd reram_bitcell_7
Xbit_r18_c16 bl[16] br[16] wl[18] gnd reram_bitcell_7
Xbit_r19_c16 bl[16] br[16] wl[19] gnd reram_bitcell_7
Xbit_r20_c16 bl[16] br[16] wl[20] gnd reram_bitcell_7
Xbit_r21_c16 bl[16] br[16] wl[21] gnd reram_bitcell_7
Xbit_r22_c16 bl[16] br[16] wl[22] gnd reram_bitcell_7
Xbit_r23_c16 bl[16] br[16] wl[23] gnd reram_bitcell_7
Xbit_r24_c16 bl[16] br[16] wl[24] gnd reram_bitcell_7
Xbit_r25_c16 bl[16] br[16] wl[25] gnd reram_bitcell_7
Xbit_r26_c16 bl[16] br[16] wl[26] gnd reram_bitcell_7
Xbit_r27_c16 bl[16] br[16] wl[27] gnd reram_bitcell_7
Xbit_r28_c16 bl[16] br[16] wl[28] gnd reram_bitcell_7
Xbit_r29_c16 bl[16] br[16] wl[29] gnd reram_bitcell_7
Xbit_r30_c16 bl[16] br[16] wl[30] gnd reram_bitcell_7
Xbit_r31_c16 bl[16] br[16] wl[31] gnd reram_bitcell_7
Xbit_r0_c17 bl[17] br[17] wl[0] gnd reram_bitcell_7
Xbit_r1_c17 bl[17] br[17] wl[1] gnd reram_bitcell_7
Xbit_r2_c17 bl[17] br[17] wl[2] gnd reram_bitcell_7
Xbit_r3_c17 bl[17] br[17] wl[3] gnd reram_bitcell_7
Xbit_r4_c17 bl[17] br[17] wl[4] gnd reram_bitcell_7
Xbit_r5_c17 bl[17] br[17] wl[5] gnd reram_bitcell_7
Xbit_r6_c17 bl[17] br[17] wl[6] gnd reram_bitcell_7
Xbit_r7_c17 bl[17] br[17] wl[7] gnd reram_bitcell_7
Xbit_r8_c17 bl[17] br[17] wl[8] gnd reram_bitcell_7
Xbit_r9_c17 bl[17] br[17] wl[9] gnd reram_bitcell_7
Xbit_r10_c17 bl[17] br[17] wl[10] gnd reram_bitcell_7
Xbit_r11_c17 bl[17] br[17] wl[11] gnd reram_bitcell_7
Xbit_r12_c17 bl[17] br[17] wl[12] gnd reram_bitcell_7
Xbit_r13_c17 bl[17] br[17] wl[13] gnd reram_bitcell_7
Xbit_r14_c17 bl[17] br[17] wl[14] gnd reram_bitcell_7
Xbit_r15_c17 bl[17] br[17] wl[15] gnd reram_bitcell_7
Xbit_r16_c17 bl[17] br[17] wl[16] gnd reram_bitcell_7
Xbit_r17_c17 bl[17] br[17] wl[17] gnd reram_bitcell_7
Xbit_r18_c17 bl[17] br[17] wl[18] gnd reram_bitcell_7
Xbit_r19_c17 bl[17] br[17] wl[19] gnd reram_bitcell_7
Xbit_r20_c17 bl[17] br[17] wl[20] gnd reram_bitcell_7
Xbit_r21_c17 bl[17] br[17] wl[21] gnd reram_bitcell_7
Xbit_r22_c17 bl[17] br[17] wl[22] gnd reram_bitcell_7
Xbit_r23_c17 bl[17] br[17] wl[23] gnd reram_bitcell_7
Xbit_r24_c17 bl[17] br[17] wl[24] gnd reram_bitcell_7
Xbit_r25_c17 bl[17] br[17] wl[25] gnd reram_bitcell_7
Xbit_r26_c17 bl[17] br[17] wl[26] gnd reram_bitcell_7
Xbit_r27_c17 bl[17] br[17] wl[27] gnd reram_bitcell_7
Xbit_r28_c17 bl[17] br[17] wl[28] gnd reram_bitcell_7
Xbit_r29_c17 bl[17] br[17] wl[29] gnd reram_bitcell_7
Xbit_r30_c17 bl[17] br[17] wl[30] gnd reram_bitcell_7
Xbit_r31_c17 bl[17] br[17] wl[31] gnd reram_bitcell_7
Xbit_r0_c18 bl[18] br[18] wl[0] gnd reram_bitcell_7
Xbit_r1_c18 bl[18] br[18] wl[1] gnd reram_bitcell_7
Xbit_r2_c18 bl[18] br[18] wl[2] gnd reram_bitcell_7
Xbit_r3_c18 bl[18] br[18] wl[3] gnd reram_bitcell_7
Xbit_r4_c18 bl[18] br[18] wl[4] gnd reram_bitcell_7
Xbit_r5_c18 bl[18] br[18] wl[5] gnd reram_bitcell_7
Xbit_r6_c18 bl[18] br[18] wl[6] gnd reram_bitcell_7
Xbit_r7_c18 bl[18] br[18] wl[7] gnd reram_bitcell_7
Xbit_r8_c18 bl[18] br[18] wl[8] gnd reram_bitcell_7
Xbit_r9_c18 bl[18] br[18] wl[9] gnd reram_bitcell_7
Xbit_r10_c18 bl[18] br[18] wl[10] gnd reram_bitcell_7
Xbit_r11_c18 bl[18] br[18] wl[11] gnd reram_bitcell_7
Xbit_r12_c18 bl[18] br[18] wl[12] gnd reram_bitcell_7
Xbit_r13_c18 bl[18] br[18] wl[13] gnd reram_bitcell_7
Xbit_r14_c18 bl[18] br[18] wl[14] gnd reram_bitcell_7
Xbit_r15_c18 bl[18] br[18] wl[15] gnd reram_bitcell_7
Xbit_r16_c18 bl[18] br[18] wl[16] gnd reram_bitcell_7
Xbit_r17_c18 bl[18] br[18] wl[17] gnd reram_bitcell_7
Xbit_r18_c18 bl[18] br[18] wl[18] gnd reram_bitcell_7
Xbit_r19_c18 bl[18] br[18] wl[19] gnd reram_bitcell_7
Xbit_r20_c18 bl[18] br[18] wl[20] gnd reram_bitcell_7
Xbit_r21_c18 bl[18] br[18] wl[21] gnd reram_bitcell_7
Xbit_r22_c18 bl[18] br[18] wl[22] gnd reram_bitcell_7
Xbit_r23_c18 bl[18] br[18] wl[23] gnd reram_bitcell_7
Xbit_r24_c18 bl[18] br[18] wl[24] gnd reram_bitcell_7
Xbit_r25_c18 bl[18] br[18] wl[25] gnd reram_bitcell_7
Xbit_r26_c18 bl[18] br[18] wl[26] gnd reram_bitcell_7
Xbit_r27_c18 bl[18] br[18] wl[27] gnd reram_bitcell_7
Xbit_r28_c18 bl[18] br[18] wl[28] gnd reram_bitcell_7
Xbit_r29_c18 bl[18] br[18] wl[29] gnd reram_bitcell_7
Xbit_r30_c18 bl[18] br[18] wl[30] gnd reram_bitcell_7
Xbit_r31_c18 bl[18] br[18] wl[31] gnd reram_bitcell_7
Xbit_r0_c19 bl[19] br[19] wl[0] gnd reram_bitcell_7
Xbit_r1_c19 bl[19] br[19] wl[1] gnd reram_bitcell_7
Xbit_r2_c19 bl[19] br[19] wl[2] gnd reram_bitcell_7
Xbit_r3_c19 bl[19] br[19] wl[3] gnd reram_bitcell_7
Xbit_r4_c19 bl[19] br[19] wl[4] gnd reram_bitcell_7
Xbit_r5_c19 bl[19] br[19] wl[5] gnd reram_bitcell_7
Xbit_r6_c19 bl[19] br[19] wl[6] gnd reram_bitcell_7
Xbit_r7_c19 bl[19] br[19] wl[7] gnd reram_bitcell_7
Xbit_r8_c19 bl[19] br[19] wl[8] gnd reram_bitcell_7
Xbit_r9_c19 bl[19] br[19] wl[9] gnd reram_bitcell_7
Xbit_r10_c19 bl[19] br[19] wl[10] gnd reram_bitcell_7
Xbit_r11_c19 bl[19] br[19] wl[11] gnd reram_bitcell_7
Xbit_r12_c19 bl[19] br[19] wl[12] gnd reram_bitcell_7
Xbit_r13_c19 bl[19] br[19] wl[13] gnd reram_bitcell_7
Xbit_r14_c19 bl[19] br[19] wl[14] gnd reram_bitcell_7
Xbit_r15_c19 bl[19] br[19] wl[15] gnd reram_bitcell_7
Xbit_r16_c19 bl[19] br[19] wl[16] gnd reram_bitcell_7
Xbit_r17_c19 bl[19] br[19] wl[17] gnd reram_bitcell_7
Xbit_r18_c19 bl[19] br[19] wl[18] gnd reram_bitcell_7
Xbit_r19_c19 bl[19] br[19] wl[19] gnd reram_bitcell_7
Xbit_r20_c19 bl[19] br[19] wl[20] gnd reram_bitcell_7
Xbit_r21_c19 bl[19] br[19] wl[21] gnd reram_bitcell_7
Xbit_r22_c19 bl[19] br[19] wl[22] gnd reram_bitcell_7
Xbit_r23_c19 bl[19] br[19] wl[23] gnd reram_bitcell_7
Xbit_r24_c19 bl[19] br[19] wl[24] gnd reram_bitcell_7
Xbit_r25_c19 bl[19] br[19] wl[25] gnd reram_bitcell_7
Xbit_r26_c19 bl[19] br[19] wl[26] gnd reram_bitcell_7
Xbit_r27_c19 bl[19] br[19] wl[27] gnd reram_bitcell_7
Xbit_r28_c19 bl[19] br[19] wl[28] gnd reram_bitcell_7
Xbit_r29_c19 bl[19] br[19] wl[29] gnd reram_bitcell_7
Xbit_r30_c19 bl[19] br[19] wl[30] gnd reram_bitcell_7
Xbit_r31_c19 bl[19] br[19] wl[31] gnd reram_bitcell_7
Xbit_r0_c20 bl[20] br[20] wl[0] gnd reram_bitcell_7
Xbit_r1_c20 bl[20] br[20] wl[1] gnd reram_bitcell_7
Xbit_r2_c20 bl[20] br[20] wl[2] gnd reram_bitcell_7
Xbit_r3_c20 bl[20] br[20] wl[3] gnd reram_bitcell_7
Xbit_r4_c20 bl[20] br[20] wl[4] gnd reram_bitcell_7
Xbit_r5_c20 bl[20] br[20] wl[5] gnd reram_bitcell_7
Xbit_r6_c20 bl[20] br[20] wl[6] gnd reram_bitcell_7
Xbit_r7_c20 bl[20] br[20] wl[7] gnd reram_bitcell_7
Xbit_r8_c20 bl[20] br[20] wl[8] gnd reram_bitcell_7
Xbit_r9_c20 bl[20] br[20] wl[9] gnd reram_bitcell_7
Xbit_r10_c20 bl[20] br[20] wl[10] gnd reram_bitcell_7
Xbit_r11_c20 bl[20] br[20] wl[11] gnd reram_bitcell_7
Xbit_r12_c20 bl[20] br[20] wl[12] gnd reram_bitcell_7
Xbit_r13_c20 bl[20] br[20] wl[13] gnd reram_bitcell_7
Xbit_r14_c20 bl[20] br[20] wl[14] gnd reram_bitcell_7
Xbit_r15_c20 bl[20] br[20] wl[15] gnd reram_bitcell_7
Xbit_r16_c20 bl[20] br[20] wl[16] gnd reram_bitcell_7
Xbit_r17_c20 bl[20] br[20] wl[17] gnd reram_bitcell_7
Xbit_r18_c20 bl[20] br[20] wl[18] gnd reram_bitcell_7
Xbit_r19_c20 bl[20] br[20] wl[19] gnd reram_bitcell_7
Xbit_r20_c20 bl[20] br[20] wl[20] gnd reram_bitcell_7
Xbit_r21_c20 bl[20] br[20] wl[21] gnd reram_bitcell_7
Xbit_r22_c20 bl[20] br[20] wl[22] gnd reram_bitcell_7
Xbit_r23_c20 bl[20] br[20] wl[23] gnd reram_bitcell_7
Xbit_r24_c20 bl[20] br[20] wl[24] gnd reram_bitcell_7
Xbit_r25_c20 bl[20] br[20] wl[25] gnd reram_bitcell_7
Xbit_r26_c20 bl[20] br[20] wl[26] gnd reram_bitcell_7
Xbit_r27_c20 bl[20] br[20] wl[27] gnd reram_bitcell_7
Xbit_r28_c20 bl[20] br[20] wl[28] gnd reram_bitcell_7
Xbit_r29_c20 bl[20] br[20] wl[29] gnd reram_bitcell_7
Xbit_r30_c20 bl[20] br[20] wl[30] gnd reram_bitcell_7
Xbit_r31_c20 bl[20] br[20] wl[31] gnd reram_bitcell_7
Xbit_r0_c21 bl[21] br[21] wl[0] gnd reram_bitcell_7
Xbit_r1_c21 bl[21] br[21] wl[1] gnd reram_bitcell_7
Xbit_r2_c21 bl[21] br[21] wl[2] gnd reram_bitcell_7
Xbit_r3_c21 bl[21] br[21] wl[3] gnd reram_bitcell_7
Xbit_r4_c21 bl[21] br[21] wl[4] gnd reram_bitcell_7
Xbit_r5_c21 bl[21] br[21] wl[5] gnd reram_bitcell_7
Xbit_r6_c21 bl[21] br[21] wl[6] gnd reram_bitcell_7
Xbit_r7_c21 bl[21] br[21] wl[7] gnd reram_bitcell_7
Xbit_r8_c21 bl[21] br[21] wl[8] gnd reram_bitcell_7
Xbit_r9_c21 bl[21] br[21] wl[9] gnd reram_bitcell_7
Xbit_r10_c21 bl[21] br[21] wl[10] gnd reram_bitcell_7
Xbit_r11_c21 bl[21] br[21] wl[11] gnd reram_bitcell_7
Xbit_r12_c21 bl[21] br[21] wl[12] gnd reram_bitcell_7
Xbit_r13_c21 bl[21] br[21] wl[13] gnd reram_bitcell_7
Xbit_r14_c21 bl[21] br[21] wl[14] gnd reram_bitcell_7
Xbit_r15_c21 bl[21] br[21] wl[15] gnd reram_bitcell_7
Xbit_r16_c21 bl[21] br[21] wl[16] gnd reram_bitcell_7
Xbit_r17_c21 bl[21] br[21] wl[17] gnd reram_bitcell_7
Xbit_r18_c21 bl[21] br[21] wl[18] gnd reram_bitcell_7
Xbit_r19_c21 bl[21] br[21] wl[19] gnd reram_bitcell_7
Xbit_r20_c21 bl[21] br[21] wl[20] gnd reram_bitcell_7
Xbit_r21_c21 bl[21] br[21] wl[21] gnd reram_bitcell_7
Xbit_r22_c21 bl[21] br[21] wl[22] gnd reram_bitcell_7
Xbit_r23_c21 bl[21] br[21] wl[23] gnd reram_bitcell_7
Xbit_r24_c21 bl[21] br[21] wl[24] gnd reram_bitcell_7
Xbit_r25_c21 bl[21] br[21] wl[25] gnd reram_bitcell_7
Xbit_r26_c21 bl[21] br[21] wl[26] gnd reram_bitcell_7
Xbit_r27_c21 bl[21] br[21] wl[27] gnd reram_bitcell_7
Xbit_r28_c21 bl[21] br[21] wl[28] gnd reram_bitcell_7
Xbit_r29_c21 bl[21] br[21] wl[29] gnd reram_bitcell_7
Xbit_r30_c21 bl[21] br[21] wl[30] gnd reram_bitcell_7
Xbit_r31_c21 bl[21] br[21] wl[31] gnd reram_bitcell_7
Xbit_r0_c22 bl[22] br[22] wl[0] gnd reram_bitcell_7
Xbit_r1_c22 bl[22] br[22] wl[1] gnd reram_bitcell_7
Xbit_r2_c22 bl[22] br[22] wl[2] gnd reram_bitcell_7
Xbit_r3_c22 bl[22] br[22] wl[3] gnd reram_bitcell_7
Xbit_r4_c22 bl[22] br[22] wl[4] gnd reram_bitcell_7
Xbit_r5_c22 bl[22] br[22] wl[5] gnd reram_bitcell_7
Xbit_r6_c22 bl[22] br[22] wl[6] gnd reram_bitcell_7
Xbit_r7_c22 bl[22] br[22] wl[7] gnd reram_bitcell_7
Xbit_r8_c22 bl[22] br[22] wl[8] gnd reram_bitcell_7
Xbit_r9_c22 bl[22] br[22] wl[9] gnd reram_bitcell_7
Xbit_r10_c22 bl[22] br[22] wl[10] gnd reram_bitcell_7
Xbit_r11_c22 bl[22] br[22] wl[11] gnd reram_bitcell_7
Xbit_r12_c22 bl[22] br[22] wl[12] gnd reram_bitcell_7
Xbit_r13_c22 bl[22] br[22] wl[13] gnd reram_bitcell_7
Xbit_r14_c22 bl[22] br[22] wl[14] gnd reram_bitcell_7
Xbit_r15_c22 bl[22] br[22] wl[15] gnd reram_bitcell_7
Xbit_r16_c22 bl[22] br[22] wl[16] gnd reram_bitcell_7
Xbit_r17_c22 bl[22] br[22] wl[17] gnd reram_bitcell_7
Xbit_r18_c22 bl[22] br[22] wl[18] gnd reram_bitcell_7
Xbit_r19_c22 bl[22] br[22] wl[19] gnd reram_bitcell_7
Xbit_r20_c22 bl[22] br[22] wl[20] gnd reram_bitcell_7
Xbit_r21_c22 bl[22] br[22] wl[21] gnd reram_bitcell_7
Xbit_r22_c22 bl[22] br[22] wl[22] gnd reram_bitcell_7
Xbit_r23_c22 bl[22] br[22] wl[23] gnd reram_bitcell_7
Xbit_r24_c22 bl[22] br[22] wl[24] gnd reram_bitcell_7
Xbit_r25_c22 bl[22] br[22] wl[25] gnd reram_bitcell_7
Xbit_r26_c22 bl[22] br[22] wl[26] gnd reram_bitcell_7
Xbit_r27_c22 bl[22] br[22] wl[27] gnd reram_bitcell_7
Xbit_r28_c22 bl[22] br[22] wl[28] gnd reram_bitcell_7
Xbit_r29_c22 bl[22] br[22] wl[29] gnd reram_bitcell_7
Xbit_r30_c22 bl[22] br[22] wl[30] gnd reram_bitcell_7
Xbit_r31_c22 bl[22] br[22] wl[31] gnd reram_bitcell_7
Xbit_r0_c23 bl[23] br[23] wl[0] gnd reram_bitcell_7
Xbit_r1_c23 bl[23] br[23] wl[1] gnd reram_bitcell_7
Xbit_r2_c23 bl[23] br[23] wl[2] gnd reram_bitcell_7
Xbit_r3_c23 bl[23] br[23] wl[3] gnd reram_bitcell_7
Xbit_r4_c23 bl[23] br[23] wl[4] gnd reram_bitcell_7
Xbit_r5_c23 bl[23] br[23] wl[5] gnd reram_bitcell_7
Xbit_r6_c23 bl[23] br[23] wl[6] gnd reram_bitcell_7
Xbit_r7_c23 bl[23] br[23] wl[7] gnd reram_bitcell_7
Xbit_r8_c23 bl[23] br[23] wl[8] gnd reram_bitcell_7
Xbit_r9_c23 bl[23] br[23] wl[9] gnd reram_bitcell_7
Xbit_r10_c23 bl[23] br[23] wl[10] gnd reram_bitcell_7
Xbit_r11_c23 bl[23] br[23] wl[11] gnd reram_bitcell_7
Xbit_r12_c23 bl[23] br[23] wl[12] gnd reram_bitcell_7
Xbit_r13_c23 bl[23] br[23] wl[13] gnd reram_bitcell_7
Xbit_r14_c23 bl[23] br[23] wl[14] gnd reram_bitcell_7
Xbit_r15_c23 bl[23] br[23] wl[15] gnd reram_bitcell_7
Xbit_r16_c23 bl[23] br[23] wl[16] gnd reram_bitcell_7
Xbit_r17_c23 bl[23] br[23] wl[17] gnd reram_bitcell_7
Xbit_r18_c23 bl[23] br[23] wl[18] gnd reram_bitcell_7
Xbit_r19_c23 bl[23] br[23] wl[19] gnd reram_bitcell_7
Xbit_r20_c23 bl[23] br[23] wl[20] gnd reram_bitcell_7
Xbit_r21_c23 bl[23] br[23] wl[21] gnd reram_bitcell_7
Xbit_r22_c23 bl[23] br[23] wl[22] gnd reram_bitcell_7
Xbit_r23_c23 bl[23] br[23] wl[23] gnd reram_bitcell_7
Xbit_r24_c23 bl[23] br[23] wl[24] gnd reram_bitcell_7
Xbit_r25_c23 bl[23] br[23] wl[25] gnd reram_bitcell_7
Xbit_r26_c23 bl[23] br[23] wl[26] gnd reram_bitcell_7
Xbit_r27_c23 bl[23] br[23] wl[27] gnd reram_bitcell_7
Xbit_r28_c23 bl[23] br[23] wl[28] gnd reram_bitcell_7
Xbit_r29_c23 bl[23] br[23] wl[29] gnd reram_bitcell_7
Xbit_r30_c23 bl[23] br[23] wl[30] gnd reram_bitcell_7
Xbit_r31_c23 bl[23] br[23] wl[31] gnd reram_bitcell_7
Xbit_r0_c24 bl[24] br[24] wl[0] gnd reram_bitcell_7
Xbit_r1_c24 bl[24] br[24] wl[1] gnd reram_bitcell_7
Xbit_r2_c24 bl[24] br[24] wl[2] gnd reram_bitcell_7
Xbit_r3_c24 bl[24] br[24] wl[3] gnd reram_bitcell_7
Xbit_r4_c24 bl[24] br[24] wl[4] gnd reram_bitcell_7
Xbit_r5_c24 bl[24] br[24] wl[5] gnd reram_bitcell_7
Xbit_r6_c24 bl[24] br[24] wl[6] gnd reram_bitcell_7
Xbit_r7_c24 bl[24] br[24] wl[7] gnd reram_bitcell_7
Xbit_r8_c24 bl[24] br[24] wl[8] gnd reram_bitcell_7
Xbit_r9_c24 bl[24] br[24] wl[9] gnd reram_bitcell_7
Xbit_r10_c24 bl[24] br[24] wl[10] gnd reram_bitcell_7
Xbit_r11_c24 bl[24] br[24] wl[11] gnd reram_bitcell_7
Xbit_r12_c24 bl[24] br[24] wl[12] gnd reram_bitcell_7
Xbit_r13_c24 bl[24] br[24] wl[13] gnd reram_bitcell_7
Xbit_r14_c24 bl[24] br[24] wl[14] gnd reram_bitcell_7
Xbit_r15_c24 bl[24] br[24] wl[15] gnd reram_bitcell_7
Xbit_r16_c24 bl[24] br[24] wl[16] gnd reram_bitcell_7
Xbit_r17_c24 bl[24] br[24] wl[17] gnd reram_bitcell_7
Xbit_r18_c24 bl[24] br[24] wl[18] gnd reram_bitcell_7
Xbit_r19_c24 bl[24] br[24] wl[19] gnd reram_bitcell_7
Xbit_r20_c24 bl[24] br[24] wl[20] gnd reram_bitcell_7
Xbit_r21_c24 bl[24] br[24] wl[21] gnd reram_bitcell_7
Xbit_r22_c24 bl[24] br[24] wl[22] gnd reram_bitcell_7
Xbit_r23_c24 bl[24] br[24] wl[23] gnd reram_bitcell_7
Xbit_r24_c24 bl[24] br[24] wl[24] gnd reram_bitcell_7
Xbit_r25_c24 bl[24] br[24] wl[25] gnd reram_bitcell_7
Xbit_r26_c24 bl[24] br[24] wl[26] gnd reram_bitcell_7
Xbit_r27_c24 bl[24] br[24] wl[27] gnd reram_bitcell_7
Xbit_r28_c24 bl[24] br[24] wl[28] gnd reram_bitcell_7
Xbit_r29_c24 bl[24] br[24] wl[29] gnd reram_bitcell_7
Xbit_r30_c24 bl[24] br[24] wl[30] gnd reram_bitcell_7
Xbit_r31_c24 bl[24] br[24] wl[31] gnd reram_bitcell_7
Xbit_r0_c25 bl[25] br[25] wl[0] gnd reram_bitcell_7
Xbit_r1_c25 bl[25] br[25] wl[1] gnd reram_bitcell_7
Xbit_r2_c25 bl[25] br[25] wl[2] gnd reram_bitcell_7
Xbit_r3_c25 bl[25] br[25] wl[3] gnd reram_bitcell_7
Xbit_r4_c25 bl[25] br[25] wl[4] gnd reram_bitcell_7
Xbit_r5_c25 bl[25] br[25] wl[5] gnd reram_bitcell_7
Xbit_r6_c25 bl[25] br[25] wl[6] gnd reram_bitcell_7
Xbit_r7_c25 bl[25] br[25] wl[7] gnd reram_bitcell_7
Xbit_r8_c25 bl[25] br[25] wl[8] gnd reram_bitcell_7
Xbit_r9_c25 bl[25] br[25] wl[9] gnd reram_bitcell_7
Xbit_r10_c25 bl[25] br[25] wl[10] gnd reram_bitcell_7
Xbit_r11_c25 bl[25] br[25] wl[11] gnd reram_bitcell_7
Xbit_r12_c25 bl[25] br[25] wl[12] gnd reram_bitcell_7
Xbit_r13_c25 bl[25] br[25] wl[13] gnd reram_bitcell_7
Xbit_r14_c25 bl[25] br[25] wl[14] gnd reram_bitcell_7
Xbit_r15_c25 bl[25] br[25] wl[15] gnd reram_bitcell_7
Xbit_r16_c25 bl[25] br[25] wl[16] gnd reram_bitcell_7
Xbit_r17_c25 bl[25] br[25] wl[17] gnd reram_bitcell_7
Xbit_r18_c25 bl[25] br[25] wl[18] gnd reram_bitcell_7
Xbit_r19_c25 bl[25] br[25] wl[19] gnd reram_bitcell_7
Xbit_r20_c25 bl[25] br[25] wl[20] gnd reram_bitcell_7
Xbit_r21_c25 bl[25] br[25] wl[21] gnd reram_bitcell_7
Xbit_r22_c25 bl[25] br[25] wl[22] gnd reram_bitcell_7
Xbit_r23_c25 bl[25] br[25] wl[23] gnd reram_bitcell_7
Xbit_r24_c25 bl[25] br[25] wl[24] gnd reram_bitcell_7
Xbit_r25_c25 bl[25] br[25] wl[25] gnd reram_bitcell_7
Xbit_r26_c25 bl[25] br[25] wl[26] gnd reram_bitcell_7
Xbit_r27_c25 bl[25] br[25] wl[27] gnd reram_bitcell_7
Xbit_r28_c25 bl[25] br[25] wl[28] gnd reram_bitcell_7
Xbit_r29_c25 bl[25] br[25] wl[29] gnd reram_bitcell_7
Xbit_r30_c25 bl[25] br[25] wl[30] gnd reram_bitcell_7
Xbit_r31_c25 bl[25] br[25] wl[31] gnd reram_bitcell_7
Xbit_r0_c26 bl[26] br[26] wl[0] gnd reram_bitcell_7
Xbit_r1_c26 bl[26] br[26] wl[1] gnd reram_bitcell_7
Xbit_r2_c26 bl[26] br[26] wl[2] gnd reram_bitcell_7
Xbit_r3_c26 bl[26] br[26] wl[3] gnd reram_bitcell_7
Xbit_r4_c26 bl[26] br[26] wl[4] gnd reram_bitcell_7
Xbit_r5_c26 bl[26] br[26] wl[5] gnd reram_bitcell_7
Xbit_r6_c26 bl[26] br[26] wl[6] gnd reram_bitcell_7
Xbit_r7_c26 bl[26] br[26] wl[7] gnd reram_bitcell_7
Xbit_r8_c26 bl[26] br[26] wl[8] gnd reram_bitcell_7
Xbit_r9_c26 bl[26] br[26] wl[9] gnd reram_bitcell_7
Xbit_r10_c26 bl[26] br[26] wl[10] gnd reram_bitcell_7
Xbit_r11_c26 bl[26] br[26] wl[11] gnd reram_bitcell_7
Xbit_r12_c26 bl[26] br[26] wl[12] gnd reram_bitcell_7
Xbit_r13_c26 bl[26] br[26] wl[13] gnd reram_bitcell_7
Xbit_r14_c26 bl[26] br[26] wl[14] gnd reram_bitcell_7
Xbit_r15_c26 bl[26] br[26] wl[15] gnd reram_bitcell_7
Xbit_r16_c26 bl[26] br[26] wl[16] gnd reram_bitcell_7
Xbit_r17_c26 bl[26] br[26] wl[17] gnd reram_bitcell_7
Xbit_r18_c26 bl[26] br[26] wl[18] gnd reram_bitcell_7
Xbit_r19_c26 bl[26] br[26] wl[19] gnd reram_bitcell_7
Xbit_r20_c26 bl[26] br[26] wl[20] gnd reram_bitcell_7
Xbit_r21_c26 bl[26] br[26] wl[21] gnd reram_bitcell_7
Xbit_r22_c26 bl[26] br[26] wl[22] gnd reram_bitcell_7
Xbit_r23_c26 bl[26] br[26] wl[23] gnd reram_bitcell_7
Xbit_r24_c26 bl[26] br[26] wl[24] gnd reram_bitcell_7
Xbit_r25_c26 bl[26] br[26] wl[25] gnd reram_bitcell_7
Xbit_r26_c26 bl[26] br[26] wl[26] gnd reram_bitcell_7
Xbit_r27_c26 bl[26] br[26] wl[27] gnd reram_bitcell_7
Xbit_r28_c26 bl[26] br[26] wl[28] gnd reram_bitcell_7
Xbit_r29_c26 bl[26] br[26] wl[29] gnd reram_bitcell_7
Xbit_r30_c26 bl[26] br[26] wl[30] gnd reram_bitcell_7
Xbit_r31_c26 bl[26] br[26] wl[31] gnd reram_bitcell_7
Xbit_r0_c27 bl[27] br[27] wl[0] gnd reram_bitcell_7
Xbit_r1_c27 bl[27] br[27] wl[1] gnd reram_bitcell_7
Xbit_r2_c27 bl[27] br[27] wl[2] gnd reram_bitcell_7
Xbit_r3_c27 bl[27] br[27] wl[3] gnd reram_bitcell_7
Xbit_r4_c27 bl[27] br[27] wl[4] gnd reram_bitcell_7
Xbit_r5_c27 bl[27] br[27] wl[5] gnd reram_bitcell_7
Xbit_r6_c27 bl[27] br[27] wl[6] gnd reram_bitcell_7
Xbit_r7_c27 bl[27] br[27] wl[7] gnd reram_bitcell_7
Xbit_r8_c27 bl[27] br[27] wl[8] gnd reram_bitcell_7
Xbit_r9_c27 bl[27] br[27] wl[9] gnd reram_bitcell_7
Xbit_r10_c27 bl[27] br[27] wl[10] gnd reram_bitcell_7
Xbit_r11_c27 bl[27] br[27] wl[11] gnd reram_bitcell_7
Xbit_r12_c27 bl[27] br[27] wl[12] gnd reram_bitcell_7
Xbit_r13_c27 bl[27] br[27] wl[13] gnd reram_bitcell_7
Xbit_r14_c27 bl[27] br[27] wl[14] gnd reram_bitcell_7
Xbit_r15_c27 bl[27] br[27] wl[15] gnd reram_bitcell_7
Xbit_r16_c27 bl[27] br[27] wl[16] gnd reram_bitcell_7
Xbit_r17_c27 bl[27] br[27] wl[17] gnd reram_bitcell_7
Xbit_r18_c27 bl[27] br[27] wl[18] gnd reram_bitcell_7
Xbit_r19_c27 bl[27] br[27] wl[19] gnd reram_bitcell_7
Xbit_r20_c27 bl[27] br[27] wl[20] gnd reram_bitcell_7
Xbit_r21_c27 bl[27] br[27] wl[21] gnd reram_bitcell_7
Xbit_r22_c27 bl[27] br[27] wl[22] gnd reram_bitcell_7
Xbit_r23_c27 bl[27] br[27] wl[23] gnd reram_bitcell_7
Xbit_r24_c27 bl[27] br[27] wl[24] gnd reram_bitcell_7
Xbit_r25_c27 bl[27] br[27] wl[25] gnd reram_bitcell_7
Xbit_r26_c27 bl[27] br[27] wl[26] gnd reram_bitcell_7
Xbit_r27_c27 bl[27] br[27] wl[27] gnd reram_bitcell_7
Xbit_r28_c27 bl[27] br[27] wl[28] gnd reram_bitcell_7
Xbit_r29_c27 bl[27] br[27] wl[29] gnd reram_bitcell_7
Xbit_r30_c27 bl[27] br[27] wl[30] gnd reram_bitcell_7
Xbit_r31_c27 bl[27] br[27] wl[31] gnd reram_bitcell_7
Xbit_r0_c28 bl[28] br[28] wl[0] gnd reram_bitcell_7
Xbit_r1_c28 bl[28] br[28] wl[1] gnd reram_bitcell_7
Xbit_r2_c28 bl[28] br[28] wl[2] gnd reram_bitcell_7
Xbit_r3_c28 bl[28] br[28] wl[3] gnd reram_bitcell_7
Xbit_r4_c28 bl[28] br[28] wl[4] gnd reram_bitcell_7
Xbit_r5_c28 bl[28] br[28] wl[5] gnd reram_bitcell_7
Xbit_r6_c28 bl[28] br[28] wl[6] gnd reram_bitcell_7
Xbit_r7_c28 bl[28] br[28] wl[7] gnd reram_bitcell_7
Xbit_r8_c28 bl[28] br[28] wl[8] gnd reram_bitcell_7
Xbit_r9_c28 bl[28] br[28] wl[9] gnd reram_bitcell_7
Xbit_r10_c28 bl[28] br[28] wl[10] gnd reram_bitcell_7
Xbit_r11_c28 bl[28] br[28] wl[11] gnd reram_bitcell_7
Xbit_r12_c28 bl[28] br[28] wl[12] gnd reram_bitcell_7
Xbit_r13_c28 bl[28] br[28] wl[13] gnd reram_bitcell_7
Xbit_r14_c28 bl[28] br[28] wl[14] gnd reram_bitcell_7
Xbit_r15_c28 bl[28] br[28] wl[15] gnd reram_bitcell_7
Xbit_r16_c28 bl[28] br[28] wl[16] gnd reram_bitcell_7
Xbit_r17_c28 bl[28] br[28] wl[17] gnd reram_bitcell_7
Xbit_r18_c28 bl[28] br[28] wl[18] gnd reram_bitcell_7
Xbit_r19_c28 bl[28] br[28] wl[19] gnd reram_bitcell_7
Xbit_r20_c28 bl[28] br[28] wl[20] gnd reram_bitcell_7
Xbit_r21_c28 bl[28] br[28] wl[21] gnd reram_bitcell_7
Xbit_r22_c28 bl[28] br[28] wl[22] gnd reram_bitcell_7
Xbit_r23_c28 bl[28] br[28] wl[23] gnd reram_bitcell_7
Xbit_r24_c28 bl[28] br[28] wl[24] gnd reram_bitcell_7
Xbit_r25_c28 bl[28] br[28] wl[25] gnd reram_bitcell_7
Xbit_r26_c28 bl[28] br[28] wl[26] gnd reram_bitcell_7
Xbit_r27_c28 bl[28] br[28] wl[27] gnd reram_bitcell_7
Xbit_r28_c28 bl[28] br[28] wl[28] gnd reram_bitcell_7
Xbit_r29_c28 bl[28] br[28] wl[29] gnd reram_bitcell_7
Xbit_r30_c28 bl[28] br[28] wl[30] gnd reram_bitcell_7
Xbit_r31_c28 bl[28] br[28] wl[31] gnd reram_bitcell_7
Xbit_r0_c29 bl[29] br[29] wl[0] gnd reram_bitcell_7
Xbit_r1_c29 bl[29] br[29] wl[1] gnd reram_bitcell_7
Xbit_r2_c29 bl[29] br[29] wl[2] gnd reram_bitcell_7
Xbit_r3_c29 bl[29] br[29] wl[3] gnd reram_bitcell_7
Xbit_r4_c29 bl[29] br[29] wl[4] gnd reram_bitcell_7
Xbit_r5_c29 bl[29] br[29] wl[5] gnd reram_bitcell_7
Xbit_r6_c29 bl[29] br[29] wl[6] gnd reram_bitcell_7
Xbit_r7_c29 bl[29] br[29] wl[7] gnd reram_bitcell_7
Xbit_r8_c29 bl[29] br[29] wl[8] gnd reram_bitcell_7
Xbit_r9_c29 bl[29] br[29] wl[9] gnd reram_bitcell_7
Xbit_r10_c29 bl[29] br[29] wl[10] gnd reram_bitcell_7
Xbit_r11_c29 bl[29] br[29] wl[11] gnd reram_bitcell_7
Xbit_r12_c29 bl[29] br[29] wl[12] gnd reram_bitcell_7
Xbit_r13_c29 bl[29] br[29] wl[13] gnd reram_bitcell_7
Xbit_r14_c29 bl[29] br[29] wl[14] gnd reram_bitcell_7
Xbit_r15_c29 bl[29] br[29] wl[15] gnd reram_bitcell_7
Xbit_r16_c29 bl[29] br[29] wl[16] gnd reram_bitcell_7
Xbit_r17_c29 bl[29] br[29] wl[17] gnd reram_bitcell_7
Xbit_r18_c29 bl[29] br[29] wl[18] gnd reram_bitcell_7
Xbit_r19_c29 bl[29] br[29] wl[19] gnd reram_bitcell_7
Xbit_r20_c29 bl[29] br[29] wl[20] gnd reram_bitcell_7
Xbit_r21_c29 bl[29] br[29] wl[21] gnd reram_bitcell_7
Xbit_r22_c29 bl[29] br[29] wl[22] gnd reram_bitcell_7
Xbit_r23_c29 bl[29] br[29] wl[23] gnd reram_bitcell_7
Xbit_r24_c29 bl[29] br[29] wl[24] gnd reram_bitcell_7
Xbit_r25_c29 bl[29] br[29] wl[25] gnd reram_bitcell_7
Xbit_r26_c29 bl[29] br[29] wl[26] gnd reram_bitcell_7
Xbit_r27_c29 bl[29] br[29] wl[27] gnd reram_bitcell_7
Xbit_r28_c29 bl[29] br[29] wl[28] gnd reram_bitcell_7
Xbit_r29_c29 bl[29] br[29] wl[29] gnd reram_bitcell_7
Xbit_r30_c29 bl[29] br[29] wl[30] gnd reram_bitcell_7
Xbit_r31_c29 bl[29] br[29] wl[31] gnd reram_bitcell_7
Xbit_r0_c30 bl[30] br[30] wl[0] gnd reram_bitcell_7
Xbit_r1_c30 bl[30] br[30] wl[1] gnd reram_bitcell_7
Xbit_r2_c30 bl[30] br[30] wl[2] gnd reram_bitcell_7
Xbit_r3_c30 bl[30] br[30] wl[3] gnd reram_bitcell_7
Xbit_r4_c30 bl[30] br[30] wl[4] gnd reram_bitcell_7
Xbit_r5_c30 bl[30] br[30] wl[5] gnd reram_bitcell_7
Xbit_r6_c30 bl[30] br[30] wl[6] gnd reram_bitcell_7
Xbit_r7_c30 bl[30] br[30] wl[7] gnd reram_bitcell_7
Xbit_r8_c30 bl[30] br[30] wl[8] gnd reram_bitcell_7
Xbit_r9_c30 bl[30] br[30] wl[9] gnd reram_bitcell_7
Xbit_r10_c30 bl[30] br[30] wl[10] gnd reram_bitcell_7
Xbit_r11_c30 bl[30] br[30] wl[11] gnd reram_bitcell_7
Xbit_r12_c30 bl[30] br[30] wl[12] gnd reram_bitcell_7
Xbit_r13_c30 bl[30] br[30] wl[13] gnd reram_bitcell_7
Xbit_r14_c30 bl[30] br[30] wl[14] gnd reram_bitcell_7
Xbit_r15_c30 bl[30] br[30] wl[15] gnd reram_bitcell_7
Xbit_r16_c30 bl[30] br[30] wl[16] gnd reram_bitcell_7
Xbit_r17_c30 bl[30] br[30] wl[17] gnd reram_bitcell_7
Xbit_r18_c30 bl[30] br[30] wl[18] gnd reram_bitcell_7
Xbit_r19_c30 bl[30] br[30] wl[19] gnd reram_bitcell_7
Xbit_r20_c30 bl[30] br[30] wl[20] gnd reram_bitcell_7
Xbit_r21_c30 bl[30] br[30] wl[21] gnd reram_bitcell_7
Xbit_r22_c30 bl[30] br[30] wl[22] gnd reram_bitcell_7
Xbit_r23_c30 bl[30] br[30] wl[23] gnd reram_bitcell_7
Xbit_r24_c30 bl[30] br[30] wl[24] gnd reram_bitcell_7
Xbit_r25_c30 bl[30] br[30] wl[25] gnd reram_bitcell_7
Xbit_r26_c30 bl[30] br[30] wl[26] gnd reram_bitcell_7
Xbit_r27_c30 bl[30] br[30] wl[27] gnd reram_bitcell_7
Xbit_r28_c30 bl[30] br[30] wl[28] gnd reram_bitcell_7
Xbit_r29_c30 bl[30] br[30] wl[29] gnd reram_bitcell_7
Xbit_r30_c30 bl[30] br[30] wl[30] gnd reram_bitcell_7
Xbit_r31_c30 bl[30] br[30] wl[31] gnd reram_bitcell_7
Xbit_r0_c31 bl[31] br[31] wl[0] gnd reram_bitcell_7
Xbit_r1_c31 bl[31] br[31] wl[1] gnd reram_bitcell_7
Xbit_r2_c31 bl[31] br[31] wl[2] gnd reram_bitcell_7
Xbit_r3_c31 bl[31] br[31] wl[3] gnd reram_bitcell_7
Xbit_r4_c31 bl[31] br[31] wl[4] gnd reram_bitcell_7
Xbit_r5_c31 bl[31] br[31] wl[5] gnd reram_bitcell_7
Xbit_r6_c31 bl[31] br[31] wl[6] gnd reram_bitcell_7
Xbit_r7_c31 bl[31] br[31] wl[7] gnd reram_bitcell_7
Xbit_r8_c31 bl[31] br[31] wl[8] gnd reram_bitcell_7
Xbit_r9_c31 bl[31] br[31] wl[9] gnd reram_bitcell_7
Xbit_r10_c31 bl[31] br[31] wl[10] gnd reram_bitcell_7
Xbit_r11_c31 bl[31] br[31] wl[11] gnd reram_bitcell_7
Xbit_r12_c31 bl[31] br[31] wl[12] gnd reram_bitcell_7
Xbit_r13_c31 bl[31] br[31] wl[13] gnd reram_bitcell_7
Xbit_r14_c31 bl[31] br[31] wl[14] gnd reram_bitcell_7
Xbit_r15_c31 bl[31] br[31] wl[15] gnd reram_bitcell_7
Xbit_r16_c31 bl[31] br[31] wl[16] gnd reram_bitcell_7
Xbit_r17_c31 bl[31] br[31] wl[17] gnd reram_bitcell_7
Xbit_r18_c31 bl[31] br[31] wl[18] gnd reram_bitcell_7
Xbit_r19_c31 bl[31] br[31] wl[19] gnd reram_bitcell_7
Xbit_r20_c31 bl[31] br[31] wl[20] gnd reram_bitcell_7
Xbit_r21_c31 bl[31] br[31] wl[21] gnd reram_bitcell_7
Xbit_r22_c31 bl[31] br[31] wl[22] gnd reram_bitcell_7
Xbit_r23_c31 bl[31] br[31] wl[23] gnd reram_bitcell_7
Xbit_r24_c31 bl[31] br[31] wl[24] gnd reram_bitcell_7
Xbit_r25_c31 bl[31] br[31] wl[25] gnd reram_bitcell_7
Xbit_r26_c31 bl[31] br[31] wl[26] gnd reram_bitcell_7
Xbit_r27_c31 bl[31] br[31] wl[27] gnd reram_bitcell_7
Xbit_r28_c31 bl[31] br[31] wl[28] gnd reram_bitcell_7
Xbit_r29_c31 bl[31] br[31] wl[29] gnd reram_bitcell_7
Xbit_r30_c31 bl[31] br[31] wl[30] gnd reram_bitcell_7
Xbit_r31_c31 bl[31] br[31] wl[31] gnd reram_bitcell_7
.ENDS bitcell_array

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=4 w=4.32 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=1.08 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=10.8 l=0.15 pd=5.7 ps=5.7 as=1.0125000000000002 ad=1.0125000000000002

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.7 l=0.15 pd=5.7 ps=5.7 as=1.0125000000000002 ad=1.0125000000000002

.SUBCKT tri_state_6 in_bar out en en_bar vdd gnd
Xnmos0 gnd en left_mid_n gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=1.08 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405
Xnmos1 left_mid_n in_bar out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=1.08 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405
Xnmos2 gnd en right_mid_n gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=1.08 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405
Xnmos3 right_mid_n in_bar out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=1.08 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405
Xpmos0 vdd en_bar left_mid_p vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.7 l=0.15 pd=5.7 ps=5.7 as=1.0125000000000002 ad=1.0125000000000002
Xpmos1 left_mid_p in_bar out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.7 l=0.15 pd=5.7 ps=5.7 as=1.0125000000000002 ad=1.0125000000000002
Xpmos2 vdd en_bar right_mid_p vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.7 l=0.15 pd=5.7 ps=5.7 as=1.0125000000000002 ad=1.0125000000000002
Xpmos3 right_mid_p in_bar out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.7 l=0.15 pd=5.7 ps=5.7 as=1.0125000000000002 ad=1.0125000000000002
.ENDS tri_state_6

.SUBCKT tri_gate_array in_bar[0] in_bar[1] in_bar[2] in_bar[3] in_bar[4] in_bar[5] in_bar[6] in_bar[7] in_bar[8] in_bar[9] in_bar[10] in_bar[11] in_bar[12] in_bar[13] in_bar[14] in_bar[15] in_bar[16] in_bar[17] in_bar[18] in_bar[19] in_bar[20] in_bar[21] in_bar[22] in_bar[23] in_bar[24] in_bar[25] in_bar[26] in_bar[27] in_bar[28] in_bar[29] in_bar[30] in_bar[31] out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] out[8] out[9] out[10] out[11] out[12] out[13] out[14] out[15] out[16] out[17] out[18] out[19] out[20] out[21] out[22] out[23] out[24] out[25] out[26] out[27] out[28] out[29] out[30] out[31] en en_bar vdd gnd
Xmod_0 in_bar[0] out[0] en en_bar vdd gnd tri_state_6
Xmod_1 in_bar[1] out[1] en en_bar vdd gnd tri_state_6
Xmod_2 in_bar[2] out[2] en en_bar vdd gnd tri_state_6
Xmod_3 in_bar[3] out[3] en en_bar vdd gnd tri_state_6
Xmod_4 in_bar[4] out[4] en en_bar vdd gnd tri_state_6
Xmod_5 in_bar[5] out[5] en en_bar vdd gnd tri_state_6
Xmod_6 in_bar[6] out[6] en en_bar vdd gnd tri_state_6
Xmod_7 in_bar[7] out[7] en en_bar vdd gnd tri_state_6
Xmod_8 in_bar[8] out[8] en en_bar vdd gnd tri_state_6
Xmod_9 in_bar[9] out[9] en en_bar vdd gnd tri_state_6
Xmod_10 in_bar[10] out[10] en en_bar vdd gnd tri_state_6
Xmod_11 in_bar[11] out[11] en en_bar vdd gnd tri_state_6
Xmod_12 in_bar[12] out[12] en en_bar vdd gnd tri_state_6
Xmod_13 in_bar[13] out[13] en en_bar vdd gnd tri_state_6
Xmod_14 in_bar[14] out[14] en en_bar vdd gnd tri_state_6
Xmod_15 in_bar[15] out[15] en en_bar vdd gnd tri_state_6
Xmod_16 in_bar[16] out[16] en en_bar vdd gnd tri_state_6
Xmod_17 in_bar[17] out[17] en en_bar vdd gnd tri_state_6
Xmod_18 in_bar[18] out[18] en en_bar vdd gnd tri_state_6
Xmod_19 in_bar[19] out[19] en en_bar vdd gnd tri_state_6
Xmod_20 in_bar[20] out[20] en en_bar vdd gnd tri_state_6
Xmod_21 in_bar[21] out[21] en en_bar vdd gnd tri_state_6
Xmod_22 in_bar[22] out[22] en en_bar vdd gnd tri_state_6
Xmod_23 in_bar[23] out[23] en en_bar vdd gnd tri_state_6
Xmod_24 in_bar[24] out[24] en en_bar vdd gnd tri_state_6
Xmod_25 in_bar[25] out[25] en en_bar vdd gnd tri_state_6
Xmod_26 in_bar[26] out[26] en en_bar vdd gnd tri_state_6
Xmod_27 in_bar[27] out[27] en en_bar vdd gnd tri_state_6
Xmod_28 in_bar[28] out[28] en en_bar vdd gnd tri_state_6
Xmod_29 in_bar[29] out[29] en en_bar vdd gnd tri_state_6
Xmod_30 in_bar[30] out[30] en en_bar vdd gnd tri_state_6
Xmod_31 in_bar[31] out[31] en en_bar vdd gnd tri_state_6
.ENDS tri_gate_array
.subckt re_ram_sense_amp bl br dout dout_bar en gnd sampleb vclamp vclampp vdd vref
xm1 vdata vclamp bl gnd sky130_fd_pr__nfet_01v8 l=0.15 w=1.44 nf=4
+ sa=0 sb=0 sd=0 mult=1 m=1
xm2 vdata vclampp net1 vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 net1 sampleb vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 net3 vdata net2 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 dout vref net2 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 net2 en gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=1.2 nf=2
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout net3 vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.2 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm8 net3 net3 vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.2 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm9 dout_bar dout gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=2
+   sa=0 sb=0 sd=0 mult=1 m=1
xm10 dout_bar dout vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.44 nf=2
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

.SUBCKT sense_amp_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] dout[0] dout[1] dout[2] dout[3] dout[4] dout[5] dout[6] dout[7] dout[8] dout[9] dout[10] dout[11] dout[12] dout[13] dout[14] dout[15] dout[16] dout[17] dout[18] dout[19] dout[20] dout[21] dout[22] dout[23] dout[24] dout[25] dout[26] dout[27] dout[28] dout[29] dout[30] dout[31] dout_bar[0] dout_bar[1] dout_bar[2] dout_bar[3] dout_bar[4] dout_bar[5] dout_bar[6] dout_bar[7] dout_bar[8] dout_bar[9] dout_bar[10] dout_bar[11] dout_bar[12] dout_bar[13] dout_bar[14] dout_bar[15] dout_bar[16] dout_bar[17] dout_bar[18] dout_bar[19] dout_bar[20] dout_bar[21] dout_bar[22] dout_bar[23] dout_bar[24] dout_bar[25] dout_bar[26] dout_bar[27] dout_bar[28] dout_bar[29] dout_bar[30] dout_bar[31] en gnd sampleb vclamp vclampp vdd vref
Xmod_0 bl[0] br[0] dout[0] dout_bar[0] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_1 bl[1] br[1] dout[1] dout_bar[1] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_2 bl[2] br[2] dout[2] dout_bar[2] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_3 bl[3] br[3] dout[3] dout_bar[3] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_4 bl[4] br[4] dout[4] dout_bar[4] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_5 bl[5] br[5] dout[5] dout_bar[5] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_6 bl[6] br[6] dout[6] dout_bar[6] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_7 bl[7] br[7] dout[7] dout_bar[7] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_8 bl[8] br[8] dout[8] dout_bar[8] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_9 bl[9] br[9] dout[9] dout_bar[9] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_10 bl[10] br[10] dout[10] dout_bar[10] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_11 bl[11] br[11] dout[11] dout_bar[11] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_12 bl[12] br[12] dout[12] dout_bar[12] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_13 bl[13] br[13] dout[13] dout_bar[13] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_14 bl[14] br[14] dout[14] dout_bar[14] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_15 bl[15] br[15] dout[15] dout_bar[15] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_16 bl[16] br[16] dout[16] dout_bar[16] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_17 bl[17] br[17] dout[17] dout_bar[17] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_18 bl[18] br[18] dout[18] dout_bar[18] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_19 bl[19] br[19] dout[19] dout_bar[19] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_20 bl[20] br[20] dout[20] dout_bar[20] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_21 bl[21] br[21] dout[21] dout_bar[21] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_22 bl[22] br[22] dout[22] dout_bar[22] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_23 bl[23] br[23] dout[23] dout_bar[23] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_24 bl[24] br[24] dout[24] dout_bar[24] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_25 bl[25] br[25] dout[25] dout_bar[25] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_26 bl[26] br[26] dout[26] dout_bar[26] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_27 bl[27] br[27] dout[27] dout_bar[27] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_28 bl[28] br[28] dout[28] dout_bar[28] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_29 bl[29] br[29] dout[29] dout_bar[29] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_30 bl[30] br[30] dout[30] dout_bar[30] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_31 bl[31] br[31] dout[31] dout_bar[31] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
.ENDS sense_amp_array

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375

.SUBCKT pinv_1_no_p_no_n_align_same_line A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1_no_p_no_n_align_same_line

.SUBCKT pnand2_1_no_p_no_n_align_same_line A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pnand2_1_no_p_no_n_align_same_line

.SUBCKT pnand3_1_no_p_no_n_align_same_line A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pnand3_1_no_p_no_n_align_same_line
.subckt ms_flop_horz_pitch din dout dout_bar clk vdd gnd
xm1 clk_buf clk_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 clk_buf clk_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 clk_bar clk gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm3 clk_bar clk vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 din clk_buf vdd gnd lout lout_bar clk_bar dlatch2
x2 lout_bar clk_bar vdd gnd dout_bar dout clk_buf dlatch2
.ends
.subckt dlatch2  din clk vdd gnd dout dout_bar clk_bar
xm1 dout dout_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 dout_bar int gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 int clk dout gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 int clk_bar dout vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 int clk_bar din gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 int clk din vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout_bar int vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 dout dout_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.1500000000000004 l=0.15 pd=2.4 ps=2.4 as=0.39375000000000004 ad=0.39375000000000004

.SUBCKT pinv_3__5_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.1500000000000004 l=0.15 pd=2.4 ps=2.4 as=0.39375000000000004 ad=0.39375000000000004
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.26 l=0.15 pd=1.14 ps=1.14 as=0.1575 ad=0.1575
.ENDS pinv_3__5_h_3__2

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.8250000000000001 l=0.15 pd=1.9500000000000002 ps=1.9500000000000002 as=0.309375 ad=0.309375

.SUBCKT pnand2_1__02_no_p_no_n_h_3__2 A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.8250000000000001 l=0.15 pd=1.9500000000000002 ps=1.9500000000000002 as=0.309375 ad=0.309375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.8250000000000001 l=0.15 pd=1.9500000000000002 ps=1.9500000000000002 as=0.309375 ad=0.309375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.66 l=0.15 pd=1.62 ps=1.62 as=0.2475 ad=0.2475
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.66 l=0.15 pd=1.62 ps=1.62 as=0.2475 ad=0.2475
.ENDS pnand2_1__02_no_p_no_n_h_3__2

.SUBCKT buffer_stage_3__5_no_out_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_3__5_h_3__2
.ENDS buffer_stage_3__5_no_out_h_3__2

.SUBCKT pinv_3__5_h_3__2_fake_c A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.1500000000000004 l=0.15 pd=2.4 ps=2.4 as=0.39375000000000004 ad=0.39375000000000004
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.26 l=0.15 pd=1.14 ps=1.14 as=0.1575 ad=0.1575
.ENDS pinv_3__5_h_3__2_fake_c

.SUBCKT buffer_stage_3__5_no_out_h_3__2_fake_c in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_3__5_h_3__2_fake_c
.ENDS buffer_stage_3__5_no_out_h_3__2_fake_c

.SUBCKT pre2x4_no_top_flops flop_in[0] flop_in[1] out[0] out[1] out[2] out[3] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_3__5_no_out_h_3__2_fake_c
Xpre2x4_nand_0 inbar[0] inbar[1] Z[0] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_1 in[0] inbar[1] Z[1] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_2 inbar[0] in[1] Z[2] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
Xpre2x4_nand_3 in[0] in[1] Z[3] vdd gnd pnand2_1__02_no_p_no_n_h_3__2
.ENDS pre2x4_no_top_flops

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025

.SUBCKT pnand3_1_no_p_no_n_h_3__2 A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
.ENDS pnand3_1_no_p_no_n_h_3__2

.SUBCKT pre3x8_no_top_flops flop_in[0] flop_in[1] flop_in[2] out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xflop_2 flop_in[2] in[2] inbar[2] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_4 Z[4] out[4] Z[4] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_5 Z[5] out[5] Z[5] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_6 Z[6] out[6] Z[6] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_7 Z[7] out[7] Z[7] vdd gnd buffer_stage_3__5_no_out_h_3__2_fake_c
Xpre3x8_nand_0 inbar[0] inbar[1] inbar[2] Z[0] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_1 in[0] inbar[1] inbar[2] Z[1] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_2 inbar[0] in[1] inbar[2] Z[2] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_3 in[0] in[1] inbar[2] Z[3] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_4 inbar[0] inbar[1] in[2] Z[4] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_5 in[0] inbar[1] in[2] Z[5] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_6 inbar[0] in[1] in[2] Z[6] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_7 in[0] in[1] in[2] Z[7] vdd gnd pnand3_1_no_p_no_n_h_3__2
.ENDS pre3x8_no_top_flops

.SUBCKT pre3x8_flops flop_in[0] flop_in[1] flop_in[2] out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xflop_2 flop_in[2] in[2] inbar[2] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_4 Z[4] out[4] Z[4] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_5 Z[5] out[5] Z[5] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_6 Z[6] out[6] Z[6] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre_nand_inv_7 Z[7] out[7] Z[7] vdd gnd buffer_stage_3__5_no_out_h_3__2
Xpre3x8_nand_0 inbar[0] inbar[1] inbar[2] Z[0] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_1 in[0] inbar[1] inbar[2] Z[1] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_2 inbar[0] in[1] inbar[2] Z[2] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_3 in[0] in[1] inbar[2] Z[3] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_4 inbar[0] inbar[1] in[2] Z[4] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_5 in[0] inbar[1] in[2] Z[5] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_6 inbar[0] in[1] in[2] Z[6] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_7 in[0] in[1] in[2] Z[7] vdd gnd pnand3_1_no_p_no_n_h_3__2
.ENDS pre3x8_flops

.SUBCKT hierarchical_decoder_32rows A[0] A[1] A[2] A[3] A[4] decode[0] decode[1] decode[2] decode[3] decode[4] decode[5] decode[6] decode[7] decode[8] decode[9] decode[10] decode[11] decode[12] decode[13] decode[14] decode[15] decode[16] decode[17] decode[18] decode[19] decode[20] decode[21] decode[22] decode[23] decode[24] decode[25] decode[26] decode[27] decode[28] decode[29] decode[30] decode[31] clk vdd gnd
Xpre_0 A[0] A[1] out[0] out[1] out[2] out[3] clk vdd gnd pre2x4_no_top_flops
Xpre_1 A[2] A[3] A[4] out[4] out[5] out[6] out[7] out[8] out[9] out[10] out[11] clk vdd gnd pre3x8_flops
XDEC_NAND[0] out[0] out[4] Z[0] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[1] out[1] out[4] Z[1] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[2] out[2] out[4] Z[2] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[3] out[3] out[4] Z[3] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[4] out[0] out[5] Z[4] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[5] out[1] out[5] Z[5] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[6] out[2] out[5] Z[6] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[7] out[3] out[5] Z[7] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[8] out[0] out[6] Z[8] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[9] out[1] out[6] Z[9] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[10] out[2] out[6] Z[10] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[11] out[3] out[6] Z[11] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[12] out[0] out[7] Z[12] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[13] out[1] out[7] Z[13] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[14] out[2] out[7] Z[14] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[15] out[3] out[7] Z[15] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[16] out[0] out[8] Z[16] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[17] out[1] out[8] Z[17] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[18] out[2] out[8] Z[18] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[19] out[3] out[8] Z[19] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[20] out[0] out[9] Z[20] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[21] out[1] out[9] Z[21] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[22] out[2] out[9] Z[22] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[23] out[3] out[9] Z[23] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[24] out[0] out[10] Z[24] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[25] out[1] out[10] Z[25] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[26] out[2] out[10] Z[26] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[27] out[3] out[10] Z[27] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[28] out[0] out[11] Z[28] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[29] out[1] out[11] Z[29] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[30] out[2] out[11] Z[30] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[31] out[3] out[11] Z[31] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_INV_[0] Z[0] decode[0] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[1] Z[1] decode[1] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[2] Z[2] decode[2] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[3] Z[3] decode[3] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[4] Z[4] decode[4] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[5] Z[5] decode[5] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[6] Z[6] decode[6] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[7] Z[7] decode[7] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[8] Z[8] decode[8] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[9] Z[9] decode[9] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[10] Z[10] decode[10] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[11] Z[11] decode[11] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[12] Z[12] decode[12] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[13] Z[13] decode[13] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[14] Z[14] decode[14] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[15] Z[15] decode[15] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[16] Z[16] decode[16] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[17] Z[17] decode[17] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[18] Z[18] decode[18] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[19] Z[19] decode[19] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[20] Z[20] decode[20] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[21] Z[21] decode[21] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[22] Z[22] decode[22] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[23] Z[23] decode[23] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[24] Z[24] decode[24] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[25] Z[25] decode[25] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[26] Z[26] decode[26] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[27] Z[27] decode[27] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[28] Z[28] decode[28] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[29] Z[29] decode[29] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[30] Z[30] decode[30] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[31] Z[31] decode[31] vdd gnd pinv_1_no_p_no_n_align_same_line
.ENDS hierarchical_decoder_32rows

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.89 l=0.15 pd=4.19 ps=4.19 as=0.729375 ad=0.729375

.SUBCKT pinv_4__31_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.89 l=0.15 pd=4.19 ps=4.19 as=0.729375 ad=0.729375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.56 l=0.15 pd=1.86 ps=1.86 as=0.2925 ad=0.2925
.ENDS pinv_4__31_no_p_no_n_align

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=5 w=11.225000000000001 l=0.15 pd=4.79 ps=4.79 as=0.841875 ad=0.841875

.SUBCKT pinv_12__5_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=5 w=11.225000000000001 l=0.15 pd=4.79 ps=4.79 as=0.841875 ad=0.841875
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=5 w=4.5 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pinv_12__5_no_p_no_n_align

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=17.99 l=0.15 pd=5.4399999999999995 ps=5.4399999999999995 as=0.9637499999999999 ad=0.9637499999999999

.SUBCKT pinv_20_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=17.99 l=0.15 pd=5.4399999999999995 ps=5.4399999999999995 as=0.9637499999999999 ad=0.9637499999999999
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=7.21 l=0.15 pd=2.36 ps=2.36 as=0.38625 ad=0.38625
.ENDS pinv_20_no_p_no_n_align

.SUBCKT buffer_stage_4__31_12__5_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_4__31_no_p_no_n_align
Xinv1 out_1 out vdd gnd pinv_12__5_no_p_no_n_align
Xinv2 out out_inv vdd gnd pinv_20_no_p_no_n_align
.ENDS buffer_stage_4__31_12__5_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align

.SUBCKT logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnand2_1_no_p_no_n_align_same_line
Xbuffer logic_out out out_inv vdd gnd buffer_stage_4__31_12__5_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align
.ENDS logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align

.SUBCKT wordline_driver_array in[0] in[1] in[2] in[3] in[4] in[5] in[6] in[7] in[8] in[9] in[10] in[11] in[12] in[13] in[14] in[15] in[16] in[17] in[18] in[19] in[20] in[21] in[22] in[23] in[24] in[25] in[26] in[27] in[28] in[29] in[30] in[31] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] en vdd gnd
Xdriver0 en in[0] wl_bar[0] wl[0] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver1 en in[1] wl_bar[1] wl[1] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver2 en in[2] wl_bar[2] wl[2] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver3 en in[3] wl_bar[3] wl[3] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver4 en in[4] wl_bar[4] wl[4] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver5 en in[5] wl_bar[5] wl[5] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver6 en in[6] wl_bar[6] wl[6] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver7 en in[7] wl_bar[7] wl[7] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver8 en in[8] wl_bar[8] wl[8] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver9 en in[9] wl_bar[9] wl[9] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver10 en in[10] wl_bar[10] wl[10] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver11 en in[11] wl_bar[11] wl[11] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver12 en in[12] wl_bar[12] wl[12] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver13 en in[13] wl_bar[13] wl[13] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver14 en in[14] wl_bar[14] wl[14] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver15 en in[15] wl_bar[15] wl[15] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver16 en in[16] wl_bar[16] wl[16] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver17 en in[17] wl_bar[17] wl[17] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver18 en in[18] wl_bar[18] wl[18] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver19 en in[19] wl_bar[19] wl[19] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver20 en in[20] wl_bar[20] wl[20] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver21 en in[21] wl_bar[21] wl[21] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver22 en in[22] wl_bar[22] wl[22] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver23 en in[23] wl_bar[23] wl[23] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver24 en in[24] wl_bar[24] wl[24] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver25 en in[25] wl_bar[25] wl[25] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver26 en in[26] wl_bar[26] wl[26] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver27 en in[27] wl_bar[27] wl[27] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver28 en in[28] wl_bar[28] wl[28] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver29 en in[29] wl_bar[29] wl[29] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver30 en in[30] wl_bar[30] wl[30] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver31 en in[31] wl_bar[31] wl[31] vdd gnd logic_buffer_pnand2_4_31_12_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
.ENDS wordline_driver_array

.SUBCKT discharge_10 bl br bl_reset br_reset gnd
Xbl_inst bl bl_reset gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xbr_inst br br_reset gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
.ENDS discharge_10

.SUBCKT precharge_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] bl_reset br_reset gnd
Xmod_0 bl[0] br[0] bl_reset br_reset gnd discharge_10
Xmod_1 bl[1] br[1] bl_reset br_reset gnd discharge_10
Xmod_2 bl[2] br[2] bl_reset br_reset gnd discharge_10
Xmod_3 bl[3] br[3] bl_reset br_reset gnd discharge_10
Xmod_4 bl[4] br[4] bl_reset br_reset gnd discharge_10
Xmod_5 bl[5] br[5] bl_reset br_reset gnd discharge_10
Xmod_6 bl[6] br[6] bl_reset br_reset gnd discharge_10
Xmod_7 bl[7] br[7] bl_reset br_reset gnd discharge_10
Xmod_8 bl[8] br[8] bl_reset br_reset gnd discharge_10
Xmod_9 bl[9] br[9] bl_reset br_reset gnd discharge_10
Xmod_10 bl[10] br[10] bl_reset br_reset gnd discharge_10
Xmod_11 bl[11] br[11] bl_reset br_reset gnd discharge_10
Xmod_12 bl[12] br[12] bl_reset br_reset gnd discharge_10
Xmod_13 bl[13] br[13] bl_reset br_reset gnd discharge_10
Xmod_14 bl[14] br[14] bl_reset br_reset gnd discharge_10
Xmod_15 bl[15] br[15] bl_reset br_reset gnd discharge_10
Xmod_16 bl[16] br[16] bl_reset br_reset gnd discharge_10
Xmod_17 bl[17] br[17] bl_reset br_reset gnd discharge_10
Xmod_18 bl[18] br[18] bl_reset br_reset gnd discharge_10
Xmod_19 bl[19] br[19] bl_reset br_reset gnd discharge_10
Xmod_20 bl[20] br[20] bl_reset br_reset gnd discharge_10
Xmod_21 bl[21] br[21] bl_reset br_reset gnd discharge_10
Xmod_22 bl[22] br[22] bl_reset br_reset gnd discharge_10
Xmod_23 bl[23] br[23] bl_reset br_reset gnd discharge_10
Xmod_24 bl[24] br[24] bl_reset br_reset gnd discharge_10
Xmod_25 bl[25] br[25] bl_reset br_reset gnd discharge_10
Xmod_26 bl[26] br[26] bl_reset br_reset gnd discharge_10
Xmod_27 bl[27] br[27] bl_reset br_reset gnd discharge_10
Xmod_28 bl[28] br[28] bl_reset br_reset gnd discharge_10
Xmod_29 bl[29] br[29] bl_reset br_reset gnd discharge_10
Xmod_30 bl[30] br[30] bl_reset br_reset gnd discharge_10
Xmod_31 bl[31] br[31] bl_reset br_reset gnd discharge_10
.ENDS precharge_array

.SUBCKT pnand2_1 A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pnand2_1

.SUBCKT pnand3_1 A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pnand3_1

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pnor2_1 A B Z vdd gnd
Xpmos1 vdd A net1 vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos2 net1 B Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos3 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
Xnmos4 Z B gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pnor2_1

.SUBCKT pinv_1 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1

.SUBCKT pinv_2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_2

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=2.06 l=0.15 pd=2.36 ps=2.36 as=0.38625 ad=0.38625

.SUBCKT pinv_2__29 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=2.06 l=0.15 pd=2.36 ps=2.36 as=0.38625 ad=0.38625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=0.8300000000000001 l=0.15 pd=1.1300000000000001 ps=1.1300000000000001 as=0.155625 ad=0.155625
.ENDS pinv_2__29

.SUBCKT buffer_stage_2__29_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_2__29
.ENDS buffer_stage_2__29_no_out_h_4

.SUBCKT logic_buffer_pnand2_2_29_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B out_inv vdd gnd pnand2_1
Xbuffer out_inv out out_inv vdd gnd buffer_stage_2__29_no_out_h_4
.ENDS logic_buffer_pnand2_2_29_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=4.635 l=0.15 pd=3.3899999999999997 ps=3.3899999999999997 as=0.579375 ad=0.579375

.SUBCKT pinv_5__14 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=4.635 l=0.15 pd=3.3899999999999997 ps=3.3899999999999997 as=0.579375 ad=0.579375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.845 l=0.15 pd=1.53 ps=1.53 as=0.230625 ad=0.230625
.ENDS pinv_5__14

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=10 w=18.65 l=0.15 pd=4.03 ps=4.03 as=0.699375 ad=0.699375

.SUBCKT pinv_20__7 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=10 w=18.65 l=0.15 pd=4.03 ps=4.03 as=0.699375 ad=0.699375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=10 w=7.45 l=0.15 pd=1.79 ps=1.79 as=0.279375 ad=0.279375
.ENDS pinv_20__7

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=17 w=30.94 l=0.15 pd=3.94 ps=3.94 as=0.6825 ad=0.6825

.SUBCKT pinv_34__4 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=17 w=30.94 l=0.15 pd=3.94 ps=3.94 as=0.6825 ad=0.6825
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=17 w=12.41 l=0.15 pd=1.76 ps=1.76 as=0.27375 ad=0.27375
.ENDS pinv_34__4

.SUBCKT buffer_stage_5__14_20__7_34__4_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_5__14
Xinv1 out_1 out vdd gnd pinv_20__7
Xinv2 out out_inv vdd gnd pinv_34__4
.ENDS buffer_stage_5__14_20__7_34__4_no_out_h_4

.SUBCKT logic_buffer_pnand2_5_14_20_7_34_4_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnand2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_5__14_20__7_34__4_no_out_h_4
.ENDS logic_buffer_pnand2_5_14_20_7_34_4_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.36 l=0.15 pd=3.6599999999999997 ps=3.6599999999999997 as=0.63 ad=0.63

.SUBCKT pinv_3__73 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.36 l=0.15 pd=3.6599999999999997 ps=3.6599999999999997 as=0.63 ad=0.63
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.35 l=0.15 pd=1.6500000000000001 ps=1.6500000000000001 as=0.25312500000000004 ad=0.25312500000000004
.ENDS pinv_3__73

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=6 w=10.350000000000001 l=0.15 pd=3.75 ps=3.75 as=0.6468750000000001 ad=0.6468750000000001

.SUBCKT pinv_11__5 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=6 w=10.350000000000001 l=0.15 pd=3.75 ps=3.75 as=0.6468750000000001 ad=0.6468750000000001
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=6 w=4.140000000000001 l=0.15 pd=1.6800000000000002 ps=1.6800000000000002 as=0.25875000000000004 ad=0.25875000000000004
.ENDS pinv_11__5

.SUBCKT buffer_stage_3__73_11__5_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_3__73
Xinv1 out_inv out vdd gnd pinv_11__5
.ENDS buffer_stage_3__73_11__5_no_out_h_4

.SUBCKT logic_buffer_pnor2_3_73_11_5_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_3__73_11__5_no_out_h_4
.ENDS logic_buffer_pnor2_3_73_11_5_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.69 l=0.15 pd=3.9899999999999998 ps=3.9899999999999998 as=0.691875 ad=0.691875

.SUBCKT pinv_4__09 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.69 l=0.15 pd=3.9899999999999998 ps=3.9899999999999998 as=0.691875 ad=0.691875
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.48 l=0.15 pd=1.78 ps=1.78 as=0.27749999999999997 ad=0.27749999999999997
.ENDS pinv_4__09

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=12.530000000000001 l=0.15 pd=3.88 ps=3.88 as=0.67125 ad=0.67125

.SUBCKT pinv_13__9 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=12.530000000000001 l=0.15 pd=3.88 ps=3.88 as=0.67125 ad=0.67125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=5.005 l=0.15 pd=1.73 ps=1.73 as=0.268125 ad=0.268125
.ENDS pinv_13__9

.SUBCKT buffer_stage_4__09_13__9_1_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_4__09
Xinv1 out_1 out vdd gnd pinv_13__9
Xinv2 out out_inv vdd gnd pinv_1
.ENDS buffer_stage_4__09_13__9_1_no_out_h_4

.SUBCKT logic_buffer_pnor2_4_09_13_9_1_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_4__09_13__9_1_no_out_h_4
.ENDS logic_buffer_pnor2_4_09_13_9_1_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.945 l=0.15 pd=2.9299999999999997 ps=2.9299999999999997 as=0.493125 ad=0.493125

.SUBCKT pinv_4__39 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.945 l=0.15 pd=2.9299999999999997 ps=2.9299999999999997 as=0.493125 ad=0.493125
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.5750000000000002 l=0.15 pd=1.35 ps=1.35 as=0.19687500000000002 ad=0.19687500000000002
.ENDS pinv_4__39

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=9 w=15.12 l=0.15 pd=3.6599999999999997 ps=3.6599999999999997 as=0.63 ad=0.63

.SUBCKT pinv_16__8 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=9 w=15.12 l=0.15 pd=3.6599999999999997 ps=3.6599999999999997 as=0.63 ad=0.63
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=9 w=6.03 l=0.15 pd=1.6400000000000001 ps=1.6400000000000001 as=0.25125000000000003 ad=0.25125000000000003
.ENDS pinv_16__8

.SUBCKT buffer_stage_4__39_16__8_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_4__39
Xinv1 out_inv out vdd gnd pinv_16__8
.ENDS buffer_stage_4__39_16__8_no_out_h_4

.SUBCKT logic_buffer_pnor2_4_39_16_8_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_4__39_16__8_no_out_h_4
.ENDS logic_buffer_pnor2_4_39_16_8_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=4.605 l=0.15 pd=3.37 ps=3.37 as=0.575625 ad=0.575625

.SUBCKT pinv_5__12 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=4.605 l=0.15 pd=3.37 ps=3.37 as=0.575625 ad=0.575625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.845 l=0.15 pd=1.53 ps=1.53 as=0.230625 ad=0.230625
.ENDS pinv_5__12

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=10 w=17.75 l=0.15 pd=3.85 ps=3.85 as=0.665625 ad=0.665625

.SUBCKT pinv_19__7 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=10 w=17.75 l=0.15 pd=3.85 ps=3.85 as=0.665625 ad=0.665625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=10 w=7.1 l=0.15 pd=1.72 ps=1.72 as=0.26625 ad=0.26625
.ENDS pinv_19__7

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=20 w=36.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pinv_40 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=20 w=36.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=20 w=14.399999999999999 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_40

.SUBCKT buffer_stage_5__12_19__7_40_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_5__12
Xinv1 out_1 out vdd gnd pinv_19__7
Xinv2 out out_inv vdd gnd pinv_40
.ENDS buffer_stage_5__12_19__7_40_no_out_h_4

.SUBCKT logic_buffer_pnand3_5_12_19_7_40_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_5__12_19__7_40_no_out_h_4
.ENDS logic_buffer_pnand3_5_12_19_7_40_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.08 l=0.15 pd=3.38 ps=3.38 as=0.5775 ad=0.5775

.SUBCKT pinv_3__42 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.08 l=0.15 pd=3.38 ps=3.38 as=0.5775 ad=0.5775
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.23 l=0.15 pd=1.53 ps=1.53 as=0.230625 ad=0.230625
.ENDS pinv_3__42

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=7.0 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625

.SUBCKT pinv_7__78 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=7.0 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.8000000000000003 l=0.15 pd=1.7000000000000002 ps=1.7000000000000002 as=0.2625 ad=0.2625
.ENDS pinv_7__78

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=11.55 l=0.15 pd=3.6 ps=3.6 as=0.61875 ad=0.61875

.SUBCKT pinv_12__8 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=11.55 l=0.15 pd=3.6 ps=3.6 as=0.61875 ad=0.61875
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=4.62 l=0.15 pd=1.62 ps=1.62 as=0.2475 ad=0.2475
.ENDS pinv_12__8

.SUBCKT buffer_stage_3__42_7__78_12__8_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_3__42
Xinv1 out_1 out vdd gnd pinv_7__78
Xinv2 out out_inv vdd gnd pinv_12__8
.ENDS buffer_stage_3__42_7__78_12__8_no_out_h_4

.SUBCKT logic_buffer_pnand3_3_42_7_78_12_8_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_3__42_7__78_12__8_no_out_h_4
.ENDS logic_buffer_pnand3_3_42_7_78_12_8_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=6.0 l=0.15 pd=3.3 ps=3.3 as=0.5625 ad=0.5625

.SUBCKT pinv_6__65 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=6.0 l=0.15 pd=3.3 ps=3.3 as=0.5625 ad=0.5625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.4 l=0.15 pd=1.5 ps=1.5 as=0.22499999999999998 ad=0.22499999999999998
.ENDS pinv_6__65

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=5 w=8.45 l=0.15 pd=3.6799999999999997 ps=3.6799999999999997 as=0.63375 ad=0.63375

.SUBCKT pinv_9__39 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=5 w=8.45 l=0.15 pd=3.6799999999999997 ps=3.6799999999999997 as=0.63375 ad=0.63375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=5 w=3.375 l=0.15 pd=1.6500000000000001 ps=1.6500000000000001 as=0.25312500000000004 ad=0.25312500000000004
.ENDS pinv_9__39

.SUBCKT buffer_stage_6__65_9__39_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_6__65
Xinv1 out_inv out vdd gnd pinv_9__39
.ENDS buffer_stage_6__65_9__39_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=5 w=7.925 l=0.15 pd=3.4699999999999998 ps=3.4699999999999998 as=0.594375 ad=0.594375

.SUBCKT pinv_8__8 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=5 w=7.925 l=0.15 pd=3.4699999999999998 ps=3.4699999999999998 as=0.594375 ad=0.594375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=5 w=3.175 l=0.15 pd=1.57 ps=1.57 as=0.238125 ad=0.238125
.ENDS pinv_8__8

.SUBCKT buffer_stage_8__8_40_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_8__8
Xinv1 out_inv out vdd gnd pinv_40
.ENDS buffer_stage_8__8_40_no_out_h_4

.SUBCKT logic_buffer_pnand3_8_8_40_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1
Xbuffer logic_out out out_inv vdd gnd buffer_stage_8__8_40_no_out_h_4
.ENDS logic_buffer_pnand3_8_8_40_no_in_no_out_h_4

.SUBCKT control_buffers bank_sel read clk sense_trig decoder_clk clk_buf clk_bar wordline_en write_en sense_en tri_en tri_en_bar sample_en_bar bl_reset br_reset vdd gnd
Xdecoder_clk bank_sel clk decoder_clk_bar decoder_clk vdd gnd logic_buffer_pnand2_2_29_no_in_no_out_h_4
Xnor_read_clk read clk nor_read_clk vdd gnd pnor2_1
Xbr_reset nor_read_clk bank_sel_bar br_reset br_reset_bar vdd gnd logic_buffer_pnor2_4_39_16_8_no_in_no_out_h_4
Xclk_buf bank_sel clk clk_bar clk_buf vdd gnd logic_buffer_pnand2_5_14_20_7_34_4_no_in_no_out_h_4
Xwrite_buf read bank_sel_cbar write_en write_en_bar vdd gnd logic_buffer_pnor2_4_09_13_9_1_no_in_no_out_h_4
Xsense_amp_buf sample_bar_int sense_trig bank_sel sense_en_bar sense_en vdd gnd logic_buffer_pnand3_3_42_7_78_12_8_no_in_no_out_h_4
Xtri_en_buf sample_bar_int sense_trig bank_sel tri_en_bar tri_en vdd gnd logic_buffer_pnand3_8_8_40_no_in_no_out_h_4
Xsense_trig_bar sense_trig sense_trig_bar vdd gnd pinv_1
Xsample_bar_int bank_sel read sense_trig_bar sample_bar_int vdd gnd pnand3_1
Xsample_bar sample_bar_int sample_en_buf sample_en_bar vdd gnd buffer_stage_6__65_9__39_no_out_h_4
Xclk_bar clk clk_bar_int vdd gnd pinv_1
Xbank_sel_cbar bank_sel clk_bar_int bank_sel_cbar vdd gnd pnand2_1
Xwordline_buf sense_trig bank_sel_cbar wordline_en wordline_en_bar vdd gnd logic_buffer_pnor2_3_73_11_5_no_in_no_out_h_4
Xread_bar read read_bar vdd gnd pinv_1
Xbl_reset bank_sel clk read_bar bl_reset_bar bl_reset vdd gnd logic_buffer_pnand3_5_12_19_7_40_no_in_no_out_h_4
Xbank_sel_bar bank_sel bank_sel_bar vdd gnd pinv_1
.ENDS control_buffers

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=4.8 l=0.15 pd=2.6999999999999997 ps=2.6999999999999997 as=0.44999999999999996 ad=0.44999999999999996

.SUBCKT pinv_5__32_no_p_no_n_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=4 w=4.8 l=0.15 pd=2.6999999999999997 ps=2.6999999999999997 as=0.44999999999999996 ad=0.44999999999999996
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=1.92 l=0.15 pd=1.26 ps=1.26 as=0.18 ad=0.18
.ENDS pinv_5__32_no_p_no_n_h_3__2

.SUBCKT buffer_stage_5__32_no_out_no_nwell_cont_no_pwell_cont_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_5__32_no_p_no_n_h_3__2
.ENDS buffer_stage_5__32_no_out_no_nwell_cont_no_pwell_cont_h_3__2

.SUBCKT flop_buffer_5__32_neg din clk dout vdd gnd
Xflop din flop_out flop_out_bar clk vdd gnd ms_flop_horz_pitch
Xbuffer flop_out dout dout_bar vdd gnd buffer_stage_5__32_no_out_no_nwell_cont_no_pwell_cont_h_3__2
.ENDS flop_buffer_5__32_neg

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=2.955 l=0.15 pd=2.27 ps=2.27 as=0.369375 ad=0.369375

.SUBCKT pinv_3__28_no_p_no_n_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=2.955 l=0.15 pd=2.27 ps=2.27 as=0.369375 ad=0.369375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.185 l=0.15 pd=1.09 ps=1.09 as=0.148125 ad=0.148125
.ENDS pinv_3__28_no_p_no_n_h_3__2

.SUBCKT buffer_stage_3__28_no_out_no_nwell_cont_no_pwell_cont_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_3__28_no_p_no_n_h_3__2
.ENDS buffer_stage_3__28_no_out_no_nwell_cont_no_pwell_cont_h_3__2

.SUBCKT flop_buffer_3__28 din clk dout vdd gnd
Xflop din flop_out flop_out_bar clk vdd gnd ms_flop_horz_pitch
Xbuffer flop_out_bar dout dout_bar vdd gnd buffer_stage_3__28_no_out_no_nwell_cont_no_pwell_cont_h_3__2
.ENDS flop_buffer_3__28

.SUBCKT bank DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] Csb read clk sense_trig decoder_clk vdd gnd vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] vdd_write_bl vdd_write_br vdd_wordline
Xcontrol_buffers bank_sel_buf read_buf clk sense_trig decoder_clk clk_buf clk_bar wordline_en write_en sense_en tri_en tri_en_bar sample_en_bar bl_reset br_reset vdd gnd control_buffers
Xtri_gate_array sense_out_bar[0] sense_out_bar[1] sense_out_bar[2] sense_out_bar[3] sense_out_bar[4] sense_out_bar[5] sense_out_bar[6] sense_out_bar[7] sense_out_bar[8] sense_out_bar[9] sense_out_bar[10] sense_out_bar[11] sense_out_bar[12] sense_out_bar[13] sense_out_bar[14] sense_out_bar[15] sense_out_bar[16] sense_out_bar[17] sense_out_bar[18] sense_out_bar[19] sense_out_bar[20] sense_out_bar[21] sense_out_bar[22] sense_out_bar[23] sense_out_bar[24] sense_out_bar[25] sense_out_bar[26] sense_out_bar[27] sense_out_bar[28] sense_out_bar[29] sense_out_bar[30] sense_out_bar[31] DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] tri_en tri_en_bar vdd gnd tri_gate_array
Xmask_in MASK[0] MASK[1] MASK[2] MASK[3] MASK[4] MASK[5] MASK[6] MASK[7] MASK[8] MASK[9] MASK[10] MASK[11] MASK[12] MASK[13] MASK[14] MASK[15] MASK[16] MASK[17] MASK[18] MASK[19] MASK[20] MASK[21] MASK[22] MASK[23] MASK[24] MASK[25] MASK[26] MASK[27] MASK[28] MASK[29] MASK[30] MASK[31] mask_in[0] mask_in_bar[0] mask_in[1] mask_in_bar[1] mask_in[2] mask_in_bar[2] mask_in[3] mask_in_bar[3] mask_in[4] mask_in_bar[4] mask_in[5] mask_in_bar[5] mask_in[6] mask_in_bar[6] mask_in[7] mask_in_bar[7] mask_in[8] mask_in_bar[8] mask_in[9] mask_in_bar[9] mask_in[10] mask_in_bar[10] mask_in[11] mask_in_bar[11] mask_in[12] mask_in_bar[12] mask_in[13] mask_in_bar[13] mask_in[14] mask_in_bar[14] mask_in[15] mask_in_bar[15] mask_in[16] mask_in_bar[16] mask_in[17] mask_in_bar[17] mask_in[18] mask_in_bar[18] mask_in[19] mask_in_bar[19] mask_in[20] mask_in_bar[20] mask_in[21] mask_in_bar[21] mask_in[22] mask_in_bar[22] mask_in[23] mask_in_bar[23] mask_in[24] mask_in_bar[24] mask_in[25] mask_in_bar[25] mask_in[26] mask_in_bar[26] mask_in[27] mask_in_bar[27] mask_in[28] mask_in_bar[28] mask_in[29] mask_in_bar[29] mask_in[30] mask_in_bar[30] mask_in[31] mask_in_bar[31] clk_buf vdd gnd flop_array_c32_w32_ms_flop_clk_buf_ms_flop_clk_buf_tap
Xdata_in DATA[0] DATA[1] DATA[2] DATA[3] DATA[4] DATA[5] DATA[6] DATA[7] DATA[8] DATA[9] DATA[10] DATA[11] DATA[12] DATA[13] DATA[14] DATA[15] DATA[16] DATA[17] DATA[18] DATA[19] DATA[20] DATA[21] DATA[22] DATA[23] DATA[24] DATA[25] DATA[26] DATA[27] DATA[28] DATA[29] DATA[30] DATA[31] data_in[0] data_in_bar[0] data_in[1] data_in_bar[1] data_in[2] data_in_bar[2] data_in[3] data_in_bar[3] data_in[4] data_in_bar[4] data_in[5] data_in_bar[5] data_in[6] data_in_bar[6] data_in[7] data_in_bar[7] data_in[8] data_in_bar[8] data_in[9] data_in_bar[9] data_in[10] data_in_bar[10] data_in[11] data_in_bar[11] data_in[12] data_in_bar[12] data_in[13] data_in_bar[13] data_in[14] data_in_bar[14] data_in[15] data_in_bar[15] data_in[16] data_in_bar[16] data_in[17] data_in_bar[17] data_in[18] data_in_bar[18] data_in[19] data_in_bar[19] data_in[20] data_in_bar[20] data_in[21] data_in_bar[21] data_in[22] data_in_bar[22] data_in[23] data_in_bar[23] data_in[24] data_in_bar[24] data_in[25] data_in_bar[25] data_in[26] data_in_bar[26] data_in[27] data_in_bar[27] data_in[28] data_in_bar[28] data_in[29] data_in_bar[29] data_in[30] data_in_bar[30] data_in[31] data_in_bar[31] clk_bar vdd gnd flop_array_c32_w32_ms_flop_clk_buf_ms_flop_clk_buf_tap
Xwrite_driver_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] data_in[0] data_in[1] data_in[2] data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] data_in[8] data_in[9] data_in[10] data_in[11] data_in[12] data_in[13] data_in[14] data_in[15] data_in[16] data_in[17] data_in[18] data_in[19] data_in[20] data_in[21] data_in[22] data_in[23] data_in[24] data_in[25] data_in[26] data_in[27] data_in[28] data_in[29] data_in[30] data_in[31] data_in_bar[0] data_in_bar[1] data_in_bar[2] data_in_bar[3] data_in_bar[4] data_in_bar[5] data_in_bar[6] data_in_bar[7] data_in_bar[8] data_in_bar[9] data_in_bar[10] data_in_bar[11] data_in_bar[12] data_in_bar[13] data_in_bar[14] data_in_bar[15] data_in_bar[16] data_in_bar[17] data_in_bar[18] data_in_bar[19] data_in_bar[20] data_in_bar[21] data_in_bar[22] data_in_bar[23] data_in_bar[24] data_in_bar[25] data_in_bar[26] data_in_bar[27] data_in_bar[28] data_in_bar[29] data_in_bar[30] data_in_bar[31] mask_in[0] mask_in[1] mask_in[2] mask_in[3] mask_in[4] mask_in[5] mask_in[6] mask_in[7] mask_in[8] mask_in[9] mask_in[10] mask_in[11] mask_in[12] mask_in[13] mask_in[14] mask_in[15] mask_in[16] mask_in[17] mask_in[18] mask_in[19] mask_in[20] mask_in[21] mask_in[22] mask_in[23] mask_in[24] mask_in[25] mask_in[26] mask_in[27] mask_in[28] mask_in[29] mask_in[30] mask_in[31] write_en vdd vdd_write_bl vdd_write_br gnd write_driver_array
Xsense_amp_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] sense_out[0] sense_out[1] sense_out[2] sense_out[3] sense_out[4] sense_out[5] sense_out[6] sense_out[7] sense_out[8] sense_out[9] sense_out[10] sense_out[11] sense_out[12] sense_out[13] sense_out[14] sense_out[15] sense_out[16] sense_out[17] sense_out[18] sense_out[19] sense_out[20] sense_out[21] sense_out[22] sense_out[23] sense_out[24] sense_out[25] sense_out[26] sense_out[27] sense_out[28] sense_out[29] sense_out[30] sense_out[31] sense_out_bar[0] sense_out_bar[1] sense_out_bar[2] sense_out_bar[3] sense_out_bar[4] sense_out_bar[5] sense_out_bar[6] sense_out_bar[7] sense_out_bar[8] sense_out_bar[9] sense_out_bar[10] sense_out_bar[11] sense_out_bar[12] sense_out_bar[13] sense_out_bar[14] sense_out_bar[15] sense_out_bar[16] sense_out_bar[17] sense_out_bar[18] sense_out_bar[19] sense_out_bar[20] sense_out_bar[21] sense_out_bar[22] sense_out_bar[23] sense_out_bar[24] sense_out_bar[25] sense_out_bar[26] sense_out_bar[27] sense_out_bar[28] sense_out_bar[29] sense_out_bar[30] sense_out_bar[31] sense_en gnd sample_en_bar vclamp vclampp vdd vref sense_amp_array
Xprecharge_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] bl_reset br_reset gnd precharge_array
Xbitcell_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] vdd gnd bitcell_array
Xwordline_driver dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] wordline_en vdd_wordline gnd wordline_driver_array
Xbank_sel_buf Csb clk bank_sel_buf vdd gnd flop_buffer_5__32_neg
Xread_buf read clk read_buf vdd gnd flop_buffer_3__28
.ENDS bank

.SUBCKT r_32_w_32 DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] Csb Web clk sense_trig vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] vdd_write_bl vdd_write_br vdd_wordline ADDR[0] ADDR[1] ADDR[2] ADDR[3] ADDR[4] vdd gnd
Xbank0 DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] Csb Web clk sense_trig decoder_clk vdd gnd vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] vdd_write_bl vdd_write_br vdd_wordline bank
Xrow_decoder ADDR[0] ADDR[1] ADDR[2] ADDR[3] ADDR[4] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] decoder_clk vdd gnd hierarchical_decoder_32rows
.ENDS r_32_w_32
