*FIRST LINE IS A COMMENT

.SUBCKT reram_bitcell_7 bl br wl gnd
Xaccess be wl br gnd sky130_fd_pr__nfet_01v8 m=1 nf=4 w=7.0 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625
Xsky130_fd_pr__reram_reram_cell bl be sky130_fd_pr__reram_reram_cell
.ENDS reram_bitcell_7
.subckt ms_flop_clk_buf din dout dout_bar clk vdd gnd
xm1 clk_buf clk_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 clk_buf clk_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 clk_bar clk gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm3 clk_bar clk vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 din clk_buf vdd gnd lout lout_bar clk_bar dlatch
x2 lout_bar clk_bar vdd gnd dout_bar dout clk_buf dlatch
.ends
.subckt dlatch  din clk vdd gnd dout dout_bar clk_bar
xm1 dout dout_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 dout_bar int gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 int clk dout gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 int clk_bar dout vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 int clk_bar din gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 int clk din vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout_bar int vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 dout dout_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

.SUBCKT flop_array_c64_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap din[0] din[1] din[2] din[3] din[4] din[5] din[6] din[7] din[8] din[9] din[10] din[11] din[12] din[13] din[14] din[15] din[16] din[17] din[18] din[19] din[20] din[21] din[22] din[23] din[24] din[25] din[26] din[27] din[28] din[29] din[30] din[31] din[32] din[33] din[34] din[35] din[36] din[37] din[38] din[39] din[40] din[41] din[42] din[43] din[44] din[45] din[46] din[47] din[48] din[49] din[50] din[51] din[52] din[53] din[54] din[55] din[56] din[57] din[58] din[59] din[60] din[61] din[62] din[63] dout[0] dout_bar[0] dout[1] dout_bar[1] dout[2] dout_bar[2] dout[3] dout_bar[3] dout[4] dout_bar[4] dout[5] dout_bar[5] dout[6] dout_bar[6] dout[7] dout_bar[7] dout[8] dout_bar[8] dout[9] dout_bar[9] dout[10] dout_bar[10] dout[11] dout_bar[11] dout[12] dout_bar[12] dout[13] dout_bar[13] dout[14] dout_bar[14] dout[15] dout_bar[15] dout[16] dout_bar[16] dout[17] dout_bar[17] dout[18] dout_bar[18] dout[19] dout_bar[19] dout[20] dout_bar[20] dout[21] dout_bar[21] dout[22] dout_bar[22] dout[23] dout_bar[23] dout[24] dout_bar[24] dout[25] dout_bar[25] dout[26] dout_bar[26] dout[27] dout_bar[27] dout[28] dout_bar[28] dout[29] dout_bar[29] dout[30] dout_bar[30] dout[31] dout_bar[31] dout[32] dout_bar[32] dout[33] dout_bar[33] dout[34] dout_bar[34] dout[35] dout_bar[35] dout[36] dout_bar[36] dout[37] dout_bar[37] dout[38] dout_bar[38] dout[39] dout_bar[39] dout[40] dout_bar[40] dout[41] dout_bar[41] dout[42] dout_bar[42] dout[43] dout_bar[43] dout[44] dout_bar[44] dout[45] dout_bar[45] dout[46] dout_bar[46] dout[47] dout_bar[47] dout[48] dout_bar[48] dout[49] dout_bar[49] dout[50] dout_bar[50] dout[51] dout_bar[51] dout[52] dout_bar[52] dout[53] dout_bar[53] dout[54] dout_bar[54] dout[55] dout_bar[55] dout[56] dout_bar[56] dout[57] dout_bar[57] dout[58] dout_bar[58] dout[59] dout_bar[59] dout[60] dout_bar[60] dout[61] dout_bar[61] dout[62] dout_bar[62] dout[63] dout_bar[63] clk vdd gnd
Xmod_0 din[0] dout[0] dout_bar[0] clk vdd gnd ms_flop_clk_buf
Xmod_1 din[1] dout[1] dout_bar[1] clk vdd gnd ms_flop_clk_buf
Xmod_2 din[2] dout[2] dout_bar[2] clk vdd gnd ms_flop_clk_buf
Xmod_3 din[3] dout[3] dout_bar[3] clk vdd gnd ms_flop_clk_buf
Xmod_4 din[4] dout[4] dout_bar[4] clk vdd gnd ms_flop_clk_buf
Xmod_5 din[5] dout[5] dout_bar[5] clk vdd gnd ms_flop_clk_buf
Xmod_6 din[6] dout[6] dout_bar[6] clk vdd gnd ms_flop_clk_buf
Xmod_7 din[7] dout[7] dout_bar[7] clk vdd gnd ms_flop_clk_buf
Xmod_8 din[8] dout[8] dout_bar[8] clk vdd gnd ms_flop_clk_buf
Xmod_9 din[9] dout[9] dout_bar[9] clk vdd gnd ms_flop_clk_buf
Xmod_10 din[10] dout[10] dout_bar[10] clk vdd gnd ms_flop_clk_buf
Xmod_11 din[11] dout[11] dout_bar[11] clk vdd gnd ms_flop_clk_buf
Xmod_12 din[12] dout[12] dout_bar[12] clk vdd gnd ms_flop_clk_buf
Xmod_13 din[13] dout[13] dout_bar[13] clk vdd gnd ms_flop_clk_buf
Xmod_14 din[14] dout[14] dout_bar[14] clk vdd gnd ms_flop_clk_buf
Xmod_15 din[15] dout[15] dout_bar[15] clk vdd gnd ms_flop_clk_buf
Xmod_16 din[16] dout[16] dout_bar[16] clk vdd gnd ms_flop_clk_buf
Xmod_17 din[17] dout[17] dout_bar[17] clk vdd gnd ms_flop_clk_buf
Xmod_18 din[18] dout[18] dout_bar[18] clk vdd gnd ms_flop_clk_buf
Xmod_19 din[19] dout[19] dout_bar[19] clk vdd gnd ms_flop_clk_buf
Xmod_20 din[20] dout[20] dout_bar[20] clk vdd gnd ms_flop_clk_buf
Xmod_21 din[21] dout[21] dout_bar[21] clk vdd gnd ms_flop_clk_buf
Xmod_22 din[22] dout[22] dout_bar[22] clk vdd gnd ms_flop_clk_buf
Xmod_23 din[23] dout[23] dout_bar[23] clk vdd gnd ms_flop_clk_buf
Xmod_24 din[24] dout[24] dout_bar[24] clk vdd gnd ms_flop_clk_buf
Xmod_25 din[25] dout[25] dout_bar[25] clk vdd gnd ms_flop_clk_buf
Xmod_26 din[26] dout[26] dout_bar[26] clk vdd gnd ms_flop_clk_buf
Xmod_27 din[27] dout[27] dout_bar[27] clk vdd gnd ms_flop_clk_buf
Xmod_28 din[28] dout[28] dout_bar[28] clk vdd gnd ms_flop_clk_buf
Xmod_29 din[29] dout[29] dout_bar[29] clk vdd gnd ms_flop_clk_buf
Xmod_30 din[30] dout[30] dout_bar[30] clk vdd gnd ms_flop_clk_buf
Xmod_31 din[31] dout[31] dout_bar[31] clk vdd gnd ms_flop_clk_buf
Xmod_32 din[32] dout[32] dout_bar[32] clk vdd gnd ms_flop_clk_buf
Xmod_33 din[33] dout[33] dout_bar[33] clk vdd gnd ms_flop_clk_buf
Xmod_34 din[34] dout[34] dout_bar[34] clk vdd gnd ms_flop_clk_buf
Xmod_35 din[35] dout[35] dout_bar[35] clk vdd gnd ms_flop_clk_buf
Xmod_36 din[36] dout[36] dout_bar[36] clk vdd gnd ms_flop_clk_buf
Xmod_37 din[37] dout[37] dout_bar[37] clk vdd gnd ms_flop_clk_buf
Xmod_38 din[38] dout[38] dout_bar[38] clk vdd gnd ms_flop_clk_buf
Xmod_39 din[39] dout[39] dout_bar[39] clk vdd gnd ms_flop_clk_buf
Xmod_40 din[40] dout[40] dout_bar[40] clk vdd gnd ms_flop_clk_buf
Xmod_41 din[41] dout[41] dout_bar[41] clk vdd gnd ms_flop_clk_buf
Xmod_42 din[42] dout[42] dout_bar[42] clk vdd gnd ms_flop_clk_buf
Xmod_43 din[43] dout[43] dout_bar[43] clk vdd gnd ms_flop_clk_buf
Xmod_44 din[44] dout[44] dout_bar[44] clk vdd gnd ms_flop_clk_buf
Xmod_45 din[45] dout[45] dout_bar[45] clk vdd gnd ms_flop_clk_buf
Xmod_46 din[46] dout[46] dout_bar[46] clk vdd gnd ms_flop_clk_buf
Xmod_47 din[47] dout[47] dout_bar[47] clk vdd gnd ms_flop_clk_buf
Xmod_48 din[48] dout[48] dout_bar[48] clk vdd gnd ms_flop_clk_buf
Xmod_49 din[49] dout[49] dout_bar[49] clk vdd gnd ms_flop_clk_buf
Xmod_50 din[50] dout[50] dout_bar[50] clk vdd gnd ms_flop_clk_buf
Xmod_51 din[51] dout[51] dout_bar[51] clk vdd gnd ms_flop_clk_buf
Xmod_52 din[52] dout[52] dout_bar[52] clk vdd gnd ms_flop_clk_buf
Xmod_53 din[53] dout[53] dout_bar[53] clk vdd gnd ms_flop_clk_buf
Xmod_54 din[54] dout[54] dout_bar[54] clk vdd gnd ms_flop_clk_buf
Xmod_55 din[55] dout[55] dout_bar[55] clk vdd gnd ms_flop_clk_buf
Xmod_56 din[56] dout[56] dout_bar[56] clk vdd gnd ms_flop_clk_buf
Xmod_57 din[57] dout[57] dout_bar[57] clk vdd gnd ms_flop_clk_buf
Xmod_58 din[58] dout[58] dout_bar[58] clk vdd gnd ms_flop_clk_buf
Xmod_59 din[59] dout[59] dout_bar[59] clk vdd gnd ms_flop_clk_buf
Xmod_60 din[60] dout[60] dout_bar[60] clk vdd gnd ms_flop_clk_buf
Xmod_61 din[61] dout[61] dout_bar[61] clk vdd gnd ms_flop_clk_buf
Xmod_62 din[62] dout[62] dout_bar[62] clk vdd gnd ms_flop_clk_buf
Xmod_63 din[63] dout[63] dout_bar[63] clk vdd gnd ms_flop_clk_buf
.ENDS flop_array_c64_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.16 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=8.1 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=4 w=8.64 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=21.6 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004

.SUBCKT write_driver_1__5_6 data data_bar mask_bar en en_bar bl br vdd gnd
XM0 gnd data bl_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM1 gnd mask_bar bl_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM2 gnd data_bar br_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM3 gnd mask_bar br_bar gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.54 l=0.15 pd=1.3800000000000001 ps=1.3800000000000001 as=0.2025 ad=0.2025
XM4 bl_bar data bl_log_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM5 bl_log_mid mask_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM6 br_bar data_bar br_log_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM7 br_log_mid mask_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=2.025 l=0.15 pd=4.35 ps=4.35 as=0.7593749999999999 ad=0.7593749999999999
XM8 bl bl_bar bl_n_mid gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM9 bl_n_mid en gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM10 br br_bar br_n_mid gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM11 br_n_mid en gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=2.16 l=0.15 pd=4.62 ps=4.62 as=0.81 ad=0.81
XM12 bl bl_bar bl_p_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
XM13 bl_p_mid en_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
XM14 br br_bar br_p_mid vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
XM15 br_p_mid en_bar vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=5.4 l=0.15 pd=11.100000000000001 ps=11.100000000000001 as=2.0250000000000004 ad=2.0250000000000004
.ENDS write_driver_1__5_6

.SUBCKT write_driver_array data[0] data_bar[0] data[1] data_bar[1] data[2] data_bar[2] data[3] data_bar[3] data[4] data_bar[4] data[5] data_bar[5] data[6] data_bar[6] data[7] data_bar[7] data[8] data_bar[8] data[9] data_bar[9] data[10] data_bar[10] data[11] data_bar[11] data[12] data_bar[12] data[13] data_bar[13] data[14] data_bar[14] data[15] data_bar[15] data[16] data_bar[16] data[17] data_bar[17] data[18] data_bar[18] data[19] data_bar[19] data[20] data_bar[20] data[21] data_bar[21] data[22] data_bar[22] data[23] data_bar[23] data[24] data_bar[24] data[25] data_bar[25] data[26] data_bar[26] data[27] data_bar[27] data[28] data_bar[28] data[29] data_bar[29] data[30] data_bar[30] data[31] data_bar[31] data[32] data_bar[32] data[33] data_bar[33] data[34] data_bar[34] data[35] data_bar[35] data[36] data_bar[36] data[37] data_bar[37] data[38] data_bar[38] data[39] data_bar[39] data[40] data_bar[40] data[41] data_bar[41] data[42] data_bar[42] data[43] data_bar[43] data[44] data_bar[44] data[45] data_bar[45] data[46] data_bar[46] data[47] data_bar[47] data[48] data_bar[48] data[49] data_bar[49] data[50] data_bar[50] data[51] data_bar[51] data[52] data_bar[52] data[53] data_bar[53] data[54] data_bar[54] data[55] data_bar[55] data[56] data_bar[56] data[57] data_bar[57] data[58] data_bar[58] data[59] data_bar[59] data[60] data_bar[60] data[61] data_bar[61] data[62] data_bar[62] data[63] data_bar[63] bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] mask_bar[0] mask_bar[1] mask_bar[2] mask_bar[3] mask_bar[4] mask_bar[5] mask_bar[6] mask_bar[7] mask_bar[8] mask_bar[9] mask_bar[10] mask_bar[11] mask_bar[12] mask_bar[13] mask_bar[14] mask_bar[15] mask_bar[16] mask_bar[17] mask_bar[18] mask_bar[19] mask_bar[20] mask_bar[21] mask_bar[22] mask_bar[23] mask_bar[24] mask_bar[25] mask_bar[26] mask_bar[27] mask_bar[28] mask_bar[29] mask_bar[30] mask_bar[31] mask_bar[32] mask_bar[33] mask_bar[34] mask_bar[35] mask_bar[36] mask_bar[37] mask_bar[38] mask_bar[39] mask_bar[40] mask_bar[41] mask_bar[42] mask_bar[43] mask_bar[44] mask_bar[45] mask_bar[46] mask_bar[47] mask_bar[48] mask_bar[49] mask_bar[50] mask_bar[51] mask_bar[52] mask_bar[53] mask_bar[54] mask_bar[55] mask_bar[56] mask_bar[57] mask_bar[58] mask_bar[59] mask_bar[60] mask_bar[61] mask_bar[62] mask_bar[63] en en_bar vdd gnd
Xmod_0 data[0] data_bar[0] mask_bar[0] en en_bar bl[0] br[0] vdd gnd write_driver_1__5_6
Xmod_1 data[1] data_bar[1] mask_bar[1] en en_bar bl[1] br[1] vdd gnd write_driver_1__5_6
Xmod_2 data[2] data_bar[2] mask_bar[2] en en_bar bl[2] br[2] vdd gnd write_driver_1__5_6
Xmod_3 data[3] data_bar[3] mask_bar[3] en en_bar bl[3] br[3] vdd gnd write_driver_1__5_6
Xmod_4 data[4] data_bar[4] mask_bar[4] en en_bar bl[4] br[4] vdd gnd write_driver_1__5_6
Xmod_5 data[5] data_bar[5] mask_bar[5] en en_bar bl[5] br[5] vdd gnd write_driver_1__5_6
Xmod_6 data[6] data_bar[6] mask_bar[6] en en_bar bl[6] br[6] vdd gnd write_driver_1__5_6
Xmod_7 data[7] data_bar[7] mask_bar[7] en en_bar bl[7] br[7] vdd gnd write_driver_1__5_6
Xmod_8 data[8] data_bar[8] mask_bar[8] en en_bar bl[8] br[8] vdd gnd write_driver_1__5_6
Xmod_9 data[9] data_bar[9] mask_bar[9] en en_bar bl[9] br[9] vdd gnd write_driver_1__5_6
Xmod_10 data[10] data_bar[10] mask_bar[10] en en_bar bl[10] br[10] vdd gnd write_driver_1__5_6
Xmod_11 data[11] data_bar[11] mask_bar[11] en en_bar bl[11] br[11] vdd gnd write_driver_1__5_6
Xmod_12 data[12] data_bar[12] mask_bar[12] en en_bar bl[12] br[12] vdd gnd write_driver_1__5_6
Xmod_13 data[13] data_bar[13] mask_bar[13] en en_bar bl[13] br[13] vdd gnd write_driver_1__5_6
Xmod_14 data[14] data_bar[14] mask_bar[14] en en_bar bl[14] br[14] vdd gnd write_driver_1__5_6
Xmod_15 data[15] data_bar[15] mask_bar[15] en en_bar bl[15] br[15] vdd gnd write_driver_1__5_6
Xmod_16 data[16] data_bar[16] mask_bar[16] en en_bar bl[16] br[16] vdd gnd write_driver_1__5_6
Xmod_17 data[17] data_bar[17] mask_bar[17] en en_bar bl[17] br[17] vdd gnd write_driver_1__5_6
Xmod_18 data[18] data_bar[18] mask_bar[18] en en_bar bl[18] br[18] vdd gnd write_driver_1__5_6
Xmod_19 data[19] data_bar[19] mask_bar[19] en en_bar bl[19] br[19] vdd gnd write_driver_1__5_6
Xmod_20 data[20] data_bar[20] mask_bar[20] en en_bar bl[20] br[20] vdd gnd write_driver_1__5_6
Xmod_21 data[21] data_bar[21] mask_bar[21] en en_bar bl[21] br[21] vdd gnd write_driver_1__5_6
Xmod_22 data[22] data_bar[22] mask_bar[22] en en_bar bl[22] br[22] vdd gnd write_driver_1__5_6
Xmod_23 data[23] data_bar[23] mask_bar[23] en en_bar bl[23] br[23] vdd gnd write_driver_1__5_6
Xmod_24 data[24] data_bar[24] mask_bar[24] en en_bar bl[24] br[24] vdd gnd write_driver_1__5_6
Xmod_25 data[25] data_bar[25] mask_bar[25] en en_bar bl[25] br[25] vdd gnd write_driver_1__5_6
Xmod_26 data[26] data_bar[26] mask_bar[26] en en_bar bl[26] br[26] vdd gnd write_driver_1__5_6
Xmod_27 data[27] data_bar[27] mask_bar[27] en en_bar bl[27] br[27] vdd gnd write_driver_1__5_6
Xmod_28 data[28] data_bar[28] mask_bar[28] en en_bar bl[28] br[28] vdd gnd write_driver_1__5_6
Xmod_29 data[29] data_bar[29] mask_bar[29] en en_bar bl[29] br[29] vdd gnd write_driver_1__5_6
Xmod_30 data[30] data_bar[30] mask_bar[30] en en_bar bl[30] br[30] vdd gnd write_driver_1__5_6
Xmod_31 data[31] data_bar[31] mask_bar[31] en en_bar bl[31] br[31] vdd gnd write_driver_1__5_6
Xmod_32 data[32] data_bar[32] mask_bar[32] en en_bar bl[32] br[32] vdd gnd write_driver_1__5_6
Xmod_33 data[33] data_bar[33] mask_bar[33] en en_bar bl[33] br[33] vdd gnd write_driver_1__5_6
Xmod_34 data[34] data_bar[34] mask_bar[34] en en_bar bl[34] br[34] vdd gnd write_driver_1__5_6
Xmod_35 data[35] data_bar[35] mask_bar[35] en en_bar bl[35] br[35] vdd gnd write_driver_1__5_6
Xmod_36 data[36] data_bar[36] mask_bar[36] en en_bar bl[36] br[36] vdd gnd write_driver_1__5_6
Xmod_37 data[37] data_bar[37] mask_bar[37] en en_bar bl[37] br[37] vdd gnd write_driver_1__5_6
Xmod_38 data[38] data_bar[38] mask_bar[38] en en_bar bl[38] br[38] vdd gnd write_driver_1__5_6
Xmod_39 data[39] data_bar[39] mask_bar[39] en en_bar bl[39] br[39] vdd gnd write_driver_1__5_6
Xmod_40 data[40] data_bar[40] mask_bar[40] en en_bar bl[40] br[40] vdd gnd write_driver_1__5_6
Xmod_41 data[41] data_bar[41] mask_bar[41] en en_bar bl[41] br[41] vdd gnd write_driver_1__5_6
Xmod_42 data[42] data_bar[42] mask_bar[42] en en_bar bl[42] br[42] vdd gnd write_driver_1__5_6
Xmod_43 data[43] data_bar[43] mask_bar[43] en en_bar bl[43] br[43] vdd gnd write_driver_1__5_6
Xmod_44 data[44] data_bar[44] mask_bar[44] en en_bar bl[44] br[44] vdd gnd write_driver_1__5_6
Xmod_45 data[45] data_bar[45] mask_bar[45] en en_bar bl[45] br[45] vdd gnd write_driver_1__5_6
Xmod_46 data[46] data_bar[46] mask_bar[46] en en_bar bl[46] br[46] vdd gnd write_driver_1__5_6
Xmod_47 data[47] data_bar[47] mask_bar[47] en en_bar bl[47] br[47] vdd gnd write_driver_1__5_6
Xmod_48 data[48] data_bar[48] mask_bar[48] en en_bar bl[48] br[48] vdd gnd write_driver_1__5_6
Xmod_49 data[49] data_bar[49] mask_bar[49] en en_bar bl[49] br[49] vdd gnd write_driver_1__5_6
Xmod_50 data[50] data_bar[50] mask_bar[50] en en_bar bl[50] br[50] vdd gnd write_driver_1__5_6
Xmod_51 data[51] data_bar[51] mask_bar[51] en en_bar bl[51] br[51] vdd gnd write_driver_1__5_6
Xmod_52 data[52] data_bar[52] mask_bar[52] en en_bar bl[52] br[52] vdd gnd write_driver_1__5_6
Xmod_53 data[53] data_bar[53] mask_bar[53] en en_bar bl[53] br[53] vdd gnd write_driver_1__5_6
Xmod_54 data[54] data_bar[54] mask_bar[54] en en_bar bl[54] br[54] vdd gnd write_driver_1__5_6
Xmod_55 data[55] data_bar[55] mask_bar[55] en en_bar bl[55] br[55] vdd gnd write_driver_1__5_6
Xmod_56 data[56] data_bar[56] mask_bar[56] en en_bar bl[56] br[56] vdd gnd write_driver_1__5_6
Xmod_57 data[57] data_bar[57] mask_bar[57] en en_bar bl[57] br[57] vdd gnd write_driver_1__5_6
Xmod_58 data[58] data_bar[58] mask_bar[58] en en_bar bl[58] br[58] vdd gnd write_driver_1__5_6
Xmod_59 data[59] data_bar[59] mask_bar[59] en en_bar bl[59] br[59] vdd gnd write_driver_1__5_6
Xmod_60 data[60] data_bar[60] mask_bar[60] en en_bar bl[60] br[60] vdd gnd write_driver_1__5_6
Xmod_61 data[61] data_bar[61] mask_bar[61] en en_bar bl[61] br[61] vdd gnd write_driver_1__5_6
Xmod_62 data[62] data_bar[62] mask_bar[62] en en_bar bl[62] br[62] vdd gnd write_driver_1__5_6
Xmod_63 data[63] data_bar[63] mask_bar[63] en en_bar bl[63] br[63] vdd gnd write_driver_1__5_6
.ENDS write_driver_array

.SUBCKT bitcell_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] vdd gnd
Xbit_r0_c0 bl[0] br[0] wl[0] gnd reram_bitcell_7
Xbit_r1_c0 bl[0] br[0] wl[1] gnd reram_bitcell_7
Xbit_r2_c0 bl[0] br[0] wl[2] gnd reram_bitcell_7
Xbit_r3_c0 bl[0] br[0] wl[3] gnd reram_bitcell_7
Xbit_r4_c0 bl[0] br[0] wl[4] gnd reram_bitcell_7
Xbit_r5_c0 bl[0] br[0] wl[5] gnd reram_bitcell_7
Xbit_r6_c0 bl[0] br[0] wl[6] gnd reram_bitcell_7
Xbit_r7_c0 bl[0] br[0] wl[7] gnd reram_bitcell_7
Xbit_r8_c0 bl[0] br[0] wl[8] gnd reram_bitcell_7
Xbit_r9_c0 bl[0] br[0] wl[9] gnd reram_bitcell_7
Xbit_r10_c0 bl[0] br[0] wl[10] gnd reram_bitcell_7
Xbit_r11_c0 bl[0] br[0] wl[11] gnd reram_bitcell_7
Xbit_r12_c0 bl[0] br[0] wl[12] gnd reram_bitcell_7
Xbit_r13_c0 bl[0] br[0] wl[13] gnd reram_bitcell_7
Xbit_r14_c0 bl[0] br[0] wl[14] gnd reram_bitcell_7
Xbit_r15_c0 bl[0] br[0] wl[15] gnd reram_bitcell_7
Xbit_r16_c0 bl[0] br[0] wl[16] gnd reram_bitcell_7
Xbit_r17_c0 bl[0] br[0] wl[17] gnd reram_bitcell_7
Xbit_r18_c0 bl[0] br[0] wl[18] gnd reram_bitcell_7
Xbit_r19_c0 bl[0] br[0] wl[19] gnd reram_bitcell_7
Xbit_r20_c0 bl[0] br[0] wl[20] gnd reram_bitcell_7
Xbit_r21_c0 bl[0] br[0] wl[21] gnd reram_bitcell_7
Xbit_r22_c0 bl[0] br[0] wl[22] gnd reram_bitcell_7
Xbit_r23_c0 bl[0] br[0] wl[23] gnd reram_bitcell_7
Xbit_r24_c0 bl[0] br[0] wl[24] gnd reram_bitcell_7
Xbit_r25_c0 bl[0] br[0] wl[25] gnd reram_bitcell_7
Xbit_r26_c0 bl[0] br[0] wl[26] gnd reram_bitcell_7
Xbit_r27_c0 bl[0] br[0] wl[27] gnd reram_bitcell_7
Xbit_r28_c0 bl[0] br[0] wl[28] gnd reram_bitcell_7
Xbit_r29_c0 bl[0] br[0] wl[29] gnd reram_bitcell_7
Xbit_r30_c0 bl[0] br[0] wl[30] gnd reram_bitcell_7
Xbit_r31_c0 bl[0] br[0] wl[31] gnd reram_bitcell_7
Xbit_r0_c1 bl[1] br[1] wl[0] gnd reram_bitcell_7
Xbit_r1_c1 bl[1] br[1] wl[1] gnd reram_bitcell_7
Xbit_r2_c1 bl[1] br[1] wl[2] gnd reram_bitcell_7
Xbit_r3_c1 bl[1] br[1] wl[3] gnd reram_bitcell_7
Xbit_r4_c1 bl[1] br[1] wl[4] gnd reram_bitcell_7
Xbit_r5_c1 bl[1] br[1] wl[5] gnd reram_bitcell_7
Xbit_r6_c1 bl[1] br[1] wl[6] gnd reram_bitcell_7
Xbit_r7_c1 bl[1] br[1] wl[7] gnd reram_bitcell_7
Xbit_r8_c1 bl[1] br[1] wl[8] gnd reram_bitcell_7
Xbit_r9_c1 bl[1] br[1] wl[9] gnd reram_bitcell_7
Xbit_r10_c1 bl[1] br[1] wl[10] gnd reram_bitcell_7
Xbit_r11_c1 bl[1] br[1] wl[11] gnd reram_bitcell_7
Xbit_r12_c1 bl[1] br[1] wl[12] gnd reram_bitcell_7
Xbit_r13_c1 bl[1] br[1] wl[13] gnd reram_bitcell_7
Xbit_r14_c1 bl[1] br[1] wl[14] gnd reram_bitcell_7
Xbit_r15_c1 bl[1] br[1] wl[15] gnd reram_bitcell_7
Xbit_r16_c1 bl[1] br[1] wl[16] gnd reram_bitcell_7
Xbit_r17_c1 bl[1] br[1] wl[17] gnd reram_bitcell_7
Xbit_r18_c1 bl[1] br[1] wl[18] gnd reram_bitcell_7
Xbit_r19_c1 bl[1] br[1] wl[19] gnd reram_bitcell_7
Xbit_r20_c1 bl[1] br[1] wl[20] gnd reram_bitcell_7
Xbit_r21_c1 bl[1] br[1] wl[21] gnd reram_bitcell_7
Xbit_r22_c1 bl[1] br[1] wl[22] gnd reram_bitcell_7
Xbit_r23_c1 bl[1] br[1] wl[23] gnd reram_bitcell_7
Xbit_r24_c1 bl[1] br[1] wl[24] gnd reram_bitcell_7
Xbit_r25_c1 bl[1] br[1] wl[25] gnd reram_bitcell_7
Xbit_r26_c1 bl[1] br[1] wl[26] gnd reram_bitcell_7
Xbit_r27_c1 bl[1] br[1] wl[27] gnd reram_bitcell_7
Xbit_r28_c1 bl[1] br[1] wl[28] gnd reram_bitcell_7
Xbit_r29_c1 bl[1] br[1] wl[29] gnd reram_bitcell_7
Xbit_r30_c1 bl[1] br[1] wl[30] gnd reram_bitcell_7
Xbit_r31_c1 bl[1] br[1] wl[31] gnd reram_bitcell_7
Xbit_r0_c2 bl[2] br[2] wl[0] gnd reram_bitcell_7
Xbit_r1_c2 bl[2] br[2] wl[1] gnd reram_bitcell_7
Xbit_r2_c2 bl[2] br[2] wl[2] gnd reram_bitcell_7
Xbit_r3_c2 bl[2] br[2] wl[3] gnd reram_bitcell_7
Xbit_r4_c2 bl[2] br[2] wl[4] gnd reram_bitcell_7
Xbit_r5_c2 bl[2] br[2] wl[5] gnd reram_bitcell_7
Xbit_r6_c2 bl[2] br[2] wl[6] gnd reram_bitcell_7
Xbit_r7_c2 bl[2] br[2] wl[7] gnd reram_bitcell_7
Xbit_r8_c2 bl[2] br[2] wl[8] gnd reram_bitcell_7
Xbit_r9_c2 bl[2] br[2] wl[9] gnd reram_bitcell_7
Xbit_r10_c2 bl[2] br[2] wl[10] gnd reram_bitcell_7
Xbit_r11_c2 bl[2] br[2] wl[11] gnd reram_bitcell_7
Xbit_r12_c2 bl[2] br[2] wl[12] gnd reram_bitcell_7
Xbit_r13_c2 bl[2] br[2] wl[13] gnd reram_bitcell_7
Xbit_r14_c2 bl[2] br[2] wl[14] gnd reram_bitcell_7
Xbit_r15_c2 bl[2] br[2] wl[15] gnd reram_bitcell_7
Xbit_r16_c2 bl[2] br[2] wl[16] gnd reram_bitcell_7
Xbit_r17_c2 bl[2] br[2] wl[17] gnd reram_bitcell_7
Xbit_r18_c2 bl[2] br[2] wl[18] gnd reram_bitcell_7
Xbit_r19_c2 bl[2] br[2] wl[19] gnd reram_bitcell_7
Xbit_r20_c2 bl[2] br[2] wl[20] gnd reram_bitcell_7
Xbit_r21_c2 bl[2] br[2] wl[21] gnd reram_bitcell_7
Xbit_r22_c2 bl[2] br[2] wl[22] gnd reram_bitcell_7
Xbit_r23_c2 bl[2] br[2] wl[23] gnd reram_bitcell_7
Xbit_r24_c2 bl[2] br[2] wl[24] gnd reram_bitcell_7
Xbit_r25_c2 bl[2] br[2] wl[25] gnd reram_bitcell_7
Xbit_r26_c2 bl[2] br[2] wl[26] gnd reram_bitcell_7
Xbit_r27_c2 bl[2] br[2] wl[27] gnd reram_bitcell_7
Xbit_r28_c2 bl[2] br[2] wl[28] gnd reram_bitcell_7
Xbit_r29_c2 bl[2] br[2] wl[29] gnd reram_bitcell_7
Xbit_r30_c2 bl[2] br[2] wl[30] gnd reram_bitcell_7
Xbit_r31_c2 bl[2] br[2] wl[31] gnd reram_bitcell_7
Xbit_r0_c3 bl[3] br[3] wl[0] gnd reram_bitcell_7
Xbit_r1_c3 bl[3] br[3] wl[1] gnd reram_bitcell_7
Xbit_r2_c3 bl[3] br[3] wl[2] gnd reram_bitcell_7
Xbit_r3_c3 bl[3] br[3] wl[3] gnd reram_bitcell_7
Xbit_r4_c3 bl[3] br[3] wl[4] gnd reram_bitcell_7
Xbit_r5_c3 bl[3] br[3] wl[5] gnd reram_bitcell_7
Xbit_r6_c3 bl[3] br[3] wl[6] gnd reram_bitcell_7
Xbit_r7_c3 bl[3] br[3] wl[7] gnd reram_bitcell_7
Xbit_r8_c3 bl[3] br[3] wl[8] gnd reram_bitcell_7
Xbit_r9_c3 bl[3] br[3] wl[9] gnd reram_bitcell_7
Xbit_r10_c3 bl[3] br[3] wl[10] gnd reram_bitcell_7
Xbit_r11_c3 bl[3] br[3] wl[11] gnd reram_bitcell_7
Xbit_r12_c3 bl[3] br[3] wl[12] gnd reram_bitcell_7
Xbit_r13_c3 bl[3] br[3] wl[13] gnd reram_bitcell_7
Xbit_r14_c3 bl[3] br[3] wl[14] gnd reram_bitcell_7
Xbit_r15_c3 bl[3] br[3] wl[15] gnd reram_bitcell_7
Xbit_r16_c3 bl[3] br[3] wl[16] gnd reram_bitcell_7
Xbit_r17_c3 bl[3] br[3] wl[17] gnd reram_bitcell_7
Xbit_r18_c3 bl[3] br[3] wl[18] gnd reram_bitcell_7
Xbit_r19_c3 bl[3] br[3] wl[19] gnd reram_bitcell_7
Xbit_r20_c3 bl[3] br[3] wl[20] gnd reram_bitcell_7
Xbit_r21_c3 bl[3] br[3] wl[21] gnd reram_bitcell_7
Xbit_r22_c3 bl[3] br[3] wl[22] gnd reram_bitcell_7
Xbit_r23_c3 bl[3] br[3] wl[23] gnd reram_bitcell_7
Xbit_r24_c3 bl[3] br[3] wl[24] gnd reram_bitcell_7
Xbit_r25_c3 bl[3] br[3] wl[25] gnd reram_bitcell_7
Xbit_r26_c3 bl[3] br[3] wl[26] gnd reram_bitcell_7
Xbit_r27_c3 bl[3] br[3] wl[27] gnd reram_bitcell_7
Xbit_r28_c3 bl[3] br[3] wl[28] gnd reram_bitcell_7
Xbit_r29_c3 bl[3] br[3] wl[29] gnd reram_bitcell_7
Xbit_r30_c3 bl[3] br[3] wl[30] gnd reram_bitcell_7
Xbit_r31_c3 bl[3] br[3] wl[31] gnd reram_bitcell_7
Xbit_r0_c4 bl[4] br[4] wl[0] gnd reram_bitcell_7
Xbit_r1_c4 bl[4] br[4] wl[1] gnd reram_bitcell_7
Xbit_r2_c4 bl[4] br[4] wl[2] gnd reram_bitcell_7
Xbit_r3_c4 bl[4] br[4] wl[3] gnd reram_bitcell_7
Xbit_r4_c4 bl[4] br[4] wl[4] gnd reram_bitcell_7
Xbit_r5_c4 bl[4] br[4] wl[5] gnd reram_bitcell_7
Xbit_r6_c4 bl[4] br[4] wl[6] gnd reram_bitcell_7
Xbit_r7_c4 bl[4] br[4] wl[7] gnd reram_bitcell_7
Xbit_r8_c4 bl[4] br[4] wl[8] gnd reram_bitcell_7
Xbit_r9_c4 bl[4] br[4] wl[9] gnd reram_bitcell_7
Xbit_r10_c4 bl[4] br[4] wl[10] gnd reram_bitcell_7
Xbit_r11_c4 bl[4] br[4] wl[11] gnd reram_bitcell_7
Xbit_r12_c4 bl[4] br[4] wl[12] gnd reram_bitcell_7
Xbit_r13_c4 bl[4] br[4] wl[13] gnd reram_bitcell_7
Xbit_r14_c4 bl[4] br[4] wl[14] gnd reram_bitcell_7
Xbit_r15_c4 bl[4] br[4] wl[15] gnd reram_bitcell_7
Xbit_r16_c4 bl[4] br[4] wl[16] gnd reram_bitcell_7
Xbit_r17_c4 bl[4] br[4] wl[17] gnd reram_bitcell_7
Xbit_r18_c4 bl[4] br[4] wl[18] gnd reram_bitcell_7
Xbit_r19_c4 bl[4] br[4] wl[19] gnd reram_bitcell_7
Xbit_r20_c4 bl[4] br[4] wl[20] gnd reram_bitcell_7
Xbit_r21_c4 bl[4] br[4] wl[21] gnd reram_bitcell_7
Xbit_r22_c4 bl[4] br[4] wl[22] gnd reram_bitcell_7
Xbit_r23_c4 bl[4] br[4] wl[23] gnd reram_bitcell_7
Xbit_r24_c4 bl[4] br[4] wl[24] gnd reram_bitcell_7
Xbit_r25_c4 bl[4] br[4] wl[25] gnd reram_bitcell_7
Xbit_r26_c4 bl[4] br[4] wl[26] gnd reram_bitcell_7
Xbit_r27_c4 bl[4] br[4] wl[27] gnd reram_bitcell_7
Xbit_r28_c4 bl[4] br[4] wl[28] gnd reram_bitcell_7
Xbit_r29_c4 bl[4] br[4] wl[29] gnd reram_bitcell_7
Xbit_r30_c4 bl[4] br[4] wl[30] gnd reram_bitcell_7
Xbit_r31_c4 bl[4] br[4] wl[31] gnd reram_bitcell_7
Xbit_r0_c5 bl[5] br[5] wl[0] gnd reram_bitcell_7
Xbit_r1_c5 bl[5] br[5] wl[1] gnd reram_bitcell_7
Xbit_r2_c5 bl[5] br[5] wl[2] gnd reram_bitcell_7
Xbit_r3_c5 bl[5] br[5] wl[3] gnd reram_bitcell_7
Xbit_r4_c5 bl[5] br[5] wl[4] gnd reram_bitcell_7
Xbit_r5_c5 bl[5] br[5] wl[5] gnd reram_bitcell_7
Xbit_r6_c5 bl[5] br[5] wl[6] gnd reram_bitcell_7
Xbit_r7_c5 bl[5] br[5] wl[7] gnd reram_bitcell_7
Xbit_r8_c5 bl[5] br[5] wl[8] gnd reram_bitcell_7
Xbit_r9_c5 bl[5] br[5] wl[9] gnd reram_bitcell_7
Xbit_r10_c5 bl[5] br[5] wl[10] gnd reram_bitcell_7
Xbit_r11_c5 bl[5] br[5] wl[11] gnd reram_bitcell_7
Xbit_r12_c5 bl[5] br[5] wl[12] gnd reram_bitcell_7
Xbit_r13_c5 bl[5] br[5] wl[13] gnd reram_bitcell_7
Xbit_r14_c5 bl[5] br[5] wl[14] gnd reram_bitcell_7
Xbit_r15_c5 bl[5] br[5] wl[15] gnd reram_bitcell_7
Xbit_r16_c5 bl[5] br[5] wl[16] gnd reram_bitcell_7
Xbit_r17_c5 bl[5] br[5] wl[17] gnd reram_bitcell_7
Xbit_r18_c5 bl[5] br[5] wl[18] gnd reram_bitcell_7
Xbit_r19_c5 bl[5] br[5] wl[19] gnd reram_bitcell_7
Xbit_r20_c5 bl[5] br[5] wl[20] gnd reram_bitcell_7
Xbit_r21_c5 bl[5] br[5] wl[21] gnd reram_bitcell_7
Xbit_r22_c5 bl[5] br[5] wl[22] gnd reram_bitcell_7
Xbit_r23_c5 bl[5] br[5] wl[23] gnd reram_bitcell_7
Xbit_r24_c5 bl[5] br[5] wl[24] gnd reram_bitcell_7
Xbit_r25_c5 bl[5] br[5] wl[25] gnd reram_bitcell_7
Xbit_r26_c5 bl[5] br[5] wl[26] gnd reram_bitcell_7
Xbit_r27_c5 bl[5] br[5] wl[27] gnd reram_bitcell_7
Xbit_r28_c5 bl[5] br[5] wl[28] gnd reram_bitcell_7
Xbit_r29_c5 bl[5] br[5] wl[29] gnd reram_bitcell_7
Xbit_r30_c5 bl[5] br[5] wl[30] gnd reram_bitcell_7
Xbit_r31_c5 bl[5] br[5] wl[31] gnd reram_bitcell_7
Xbit_r0_c6 bl[6] br[6] wl[0] gnd reram_bitcell_7
Xbit_r1_c6 bl[6] br[6] wl[1] gnd reram_bitcell_7
Xbit_r2_c6 bl[6] br[6] wl[2] gnd reram_bitcell_7
Xbit_r3_c6 bl[6] br[6] wl[3] gnd reram_bitcell_7
Xbit_r4_c6 bl[6] br[6] wl[4] gnd reram_bitcell_7
Xbit_r5_c6 bl[6] br[6] wl[5] gnd reram_bitcell_7
Xbit_r6_c6 bl[6] br[6] wl[6] gnd reram_bitcell_7
Xbit_r7_c6 bl[6] br[6] wl[7] gnd reram_bitcell_7
Xbit_r8_c6 bl[6] br[6] wl[8] gnd reram_bitcell_7
Xbit_r9_c6 bl[6] br[6] wl[9] gnd reram_bitcell_7
Xbit_r10_c6 bl[6] br[6] wl[10] gnd reram_bitcell_7
Xbit_r11_c6 bl[6] br[6] wl[11] gnd reram_bitcell_7
Xbit_r12_c6 bl[6] br[6] wl[12] gnd reram_bitcell_7
Xbit_r13_c6 bl[6] br[6] wl[13] gnd reram_bitcell_7
Xbit_r14_c6 bl[6] br[6] wl[14] gnd reram_bitcell_7
Xbit_r15_c6 bl[6] br[6] wl[15] gnd reram_bitcell_7
Xbit_r16_c6 bl[6] br[6] wl[16] gnd reram_bitcell_7
Xbit_r17_c6 bl[6] br[6] wl[17] gnd reram_bitcell_7
Xbit_r18_c6 bl[6] br[6] wl[18] gnd reram_bitcell_7
Xbit_r19_c6 bl[6] br[6] wl[19] gnd reram_bitcell_7
Xbit_r20_c6 bl[6] br[6] wl[20] gnd reram_bitcell_7
Xbit_r21_c6 bl[6] br[6] wl[21] gnd reram_bitcell_7
Xbit_r22_c6 bl[6] br[6] wl[22] gnd reram_bitcell_7
Xbit_r23_c6 bl[6] br[6] wl[23] gnd reram_bitcell_7
Xbit_r24_c6 bl[6] br[6] wl[24] gnd reram_bitcell_7
Xbit_r25_c6 bl[6] br[6] wl[25] gnd reram_bitcell_7
Xbit_r26_c6 bl[6] br[6] wl[26] gnd reram_bitcell_7
Xbit_r27_c6 bl[6] br[6] wl[27] gnd reram_bitcell_7
Xbit_r28_c6 bl[6] br[6] wl[28] gnd reram_bitcell_7
Xbit_r29_c6 bl[6] br[6] wl[29] gnd reram_bitcell_7
Xbit_r30_c6 bl[6] br[6] wl[30] gnd reram_bitcell_7
Xbit_r31_c6 bl[6] br[6] wl[31] gnd reram_bitcell_7
Xbit_r0_c7 bl[7] br[7] wl[0] gnd reram_bitcell_7
Xbit_r1_c7 bl[7] br[7] wl[1] gnd reram_bitcell_7
Xbit_r2_c7 bl[7] br[7] wl[2] gnd reram_bitcell_7
Xbit_r3_c7 bl[7] br[7] wl[3] gnd reram_bitcell_7
Xbit_r4_c7 bl[7] br[7] wl[4] gnd reram_bitcell_7
Xbit_r5_c7 bl[7] br[7] wl[5] gnd reram_bitcell_7
Xbit_r6_c7 bl[7] br[7] wl[6] gnd reram_bitcell_7
Xbit_r7_c7 bl[7] br[7] wl[7] gnd reram_bitcell_7
Xbit_r8_c7 bl[7] br[7] wl[8] gnd reram_bitcell_7
Xbit_r9_c7 bl[7] br[7] wl[9] gnd reram_bitcell_7
Xbit_r10_c7 bl[7] br[7] wl[10] gnd reram_bitcell_7
Xbit_r11_c7 bl[7] br[7] wl[11] gnd reram_bitcell_7
Xbit_r12_c7 bl[7] br[7] wl[12] gnd reram_bitcell_7
Xbit_r13_c7 bl[7] br[7] wl[13] gnd reram_bitcell_7
Xbit_r14_c7 bl[7] br[7] wl[14] gnd reram_bitcell_7
Xbit_r15_c7 bl[7] br[7] wl[15] gnd reram_bitcell_7
Xbit_r16_c7 bl[7] br[7] wl[16] gnd reram_bitcell_7
Xbit_r17_c7 bl[7] br[7] wl[17] gnd reram_bitcell_7
Xbit_r18_c7 bl[7] br[7] wl[18] gnd reram_bitcell_7
Xbit_r19_c7 bl[7] br[7] wl[19] gnd reram_bitcell_7
Xbit_r20_c7 bl[7] br[7] wl[20] gnd reram_bitcell_7
Xbit_r21_c7 bl[7] br[7] wl[21] gnd reram_bitcell_7
Xbit_r22_c7 bl[7] br[7] wl[22] gnd reram_bitcell_7
Xbit_r23_c7 bl[7] br[7] wl[23] gnd reram_bitcell_7
Xbit_r24_c7 bl[7] br[7] wl[24] gnd reram_bitcell_7
Xbit_r25_c7 bl[7] br[7] wl[25] gnd reram_bitcell_7
Xbit_r26_c7 bl[7] br[7] wl[26] gnd reram_bitcell_7
Xbit_r27_c7 bl[7] br[7] wl[27] gnd reram_bitcell_7
Xbit_r28_c7 bl[7] br[7] wl[28] gnd reram_bitcell_7
Xbit_r29_c7 bl[7] br[7] wl[29] gnd reram_bitcell_7
Xbit_r30_c7 bl[7] br[7] wl[30] gnd reram_bitcell_7
Xbit_r31_c7 bl[7] br[7] wl[31] gnd reram_bitcell_7
Xbit_r0_c8 bl[8] br[8] wl[0] gnd reram_bitcell_7
Xbit_r1_c8 bl[8] br[8] wl[1] gnd reram_bitcell_7
Xbit_r2_c8 bl[8] br[8] wl[2] gnd reram_bitcell_7
Xbit_r3_c8 bl[8] br[8] wl[3] gnd reram_bitcell_7
Xbit_r4_c8 bl[8] br[8] wl[4] gnd reram_bitcell_7
Xbit_r5_c8 bl[8] br[8] wl[5] gnd reram_bitcell_7
Xbit_r6_c8 bl[8] br[8] wl[6] gnd reram_bitcell_7
Xbit_r7_c8 bl[8] br[8] wl[7] gnd reram_bitcell_7
Xbit_r8_c8 bl[8] br[8] wl[8] gnd reram_bitcell_7
Xbit_r9_c8 bl[8] br[8] wl[9] gnd reram_bitcell_7
Xbit_r10_c8 bl[8] br[8] wl[10] gnd reram_bitcell_7
Xbit_r11_c8 bl[8] br[8] wl[11] gnd reram_bitcell_7
Xbit_r12_c8 bl[8] br[8] wl[12] gnd reram_bitcell_7
Xbit_r13_c8 bl[8] br[8] wl[13] gnd reram_bitcell_7
Xbit_r14_c8 bl[8] br[8] wl[14] gnd reram_bitcell_7
Xbit_r15_c8 bl[8] br[8] wl[15] gnd reram_bitcell_7
Xbit_r16_c8 bl[8] br[8] wl[16] gnd reram_bitcell_7
Xbit_r17_c8 bl[8] br[8] wl[17] gnd reram_bitcell_7
Xbit_r18_c8 bl[8] br[8] wl[18] gnd reram_bitcell_7
Xbit_r19_c8 bl[8] br[8] wl[19] gnd reram_bitcell_7
Xbit_r20_c8 bl[8] br[8] wl[20] gnd reram_bitcell_7
Xbit_r21_c8 bl[8] br[8] wl[21] gnd reram_bitcell_7
Xbit_r22_c8 bl[8] br[8] wl[22] gnd reram_bitcell_7
Xbit_r23_c8 bl[8] br[8] wl[23] gnd reram_bitcell_7
Xbit_r24_c8 bl[8] br[8] wl[24] gnd reram_bitcell_7
Xbit_r25_c8 bl[8] br[8] wl[25] gnd reram_bitcell_7
Xbit_r26_c8 bl[8] br[8] wl[26] gnd reram_bitcell_7
Xbit_r27_c8 bl[8] br[8] wl[27] gnd reram_bitcell_7
Xbit_r28_c8 bl[8] br[8] wl[28] gnd reram_bitcell_7
Xbit_r29_c8 bl[8] br[8] wl[29] gnd reram_bitcell_7
Xbit_r30_c8 bl[8] br[8] wl[30] gnd reram_bitcell_7
Xbit_r31_c8 bl[8] br[8] wl[31] gnd reram_bitcell_7
Xbit_r0_c9 bl[9] br[9] wl[0] gnd reram_bitcell_7
Xbit_r1_c9 bl[9] br[9] wl[1] gnd reram_bitcell_7
Xbit_r2_c9 bl[9] br[9] wl[2] gnd reram_bitcell_7
Xbit_r3_c9 bl[9] br[9] wl[3] gnd reram_bitcell_7
Xbit_r4_c9 bl[9] br[9] wl[4] gnd reram_bitcell_7
Xbit_r5_c9 bl[9] br[9] wl[5] gnd reram_bitcell_7
Xbit_r6_c9 bl[9] br[9] wl[6] gnd reram_bitcell_7
Xbit_r7_c9 bl[9] br[9] wl[7] gnd reram_bitcell_7
Xbit_r8_c9 bl[9] br[9] wl[8] gnd reram_bitcell_7
Xbit_r9_c9 bl[9] br[9] wl[9] gnd reram_bitcell_7
Xbit_r10_c9 bl[9] br[9] wl[10] gnd reram_bitcell_7
Xbit_r11_c9 bl[9] br[9] wl[11] gnd reram_bitcell_7
Xbit_r12_c9 bl[9] br[9] wl[12] gnd reram_bitcell_7
Xbit_r13_c9 bl[9] br[9] wl[13] gnd reram_bitcell_7
Xbit_r14_c9 bl[9] br[9] wl[14] gnd reram_bitcell_7
Xbit_r15_c9 bl[9] br[9] wl[15] gnd reram_bitcell_7
Xbit_r16_c9 bl[9] br[9] wl[16] gnd reram_bitcell_7
Xbit_r17_c9 bl[9] br[9] wl[17] gnd reram_bitcell_7
Xbit_r18_c9 bl[9] br[9] wl[18] gnd reram_bitcell_7
Xbit_r19_c9 bl[9] br[9] wl[19] gnd reram_bitcell_7
Xbit_r20_c9 bl[9] br[9] wl[20] gnd reram_bitcell_7
Xbit_r21_c9 bl[9] br[9] wl[21] gnd reram_bitcell_7
Xbit_r22_c9 bl[9] br[9] wl[22] gnd reram_bitcell_7
Xbit_r23_c9 bl[9] br[9] wl[23] gnd reram_bitcell_7
Xbit_r24_c9 bl[9] br[9] wl[24] gnd reram_bitcell_7
Xbit_r25_c9 bl[9] br[9] wl[25] gnd reram_bitcell_7
Xbit_r26_c9 bl[9] br[9] wl[26] gnd reram_bitcell_7
Xbit_r27_c9 bl[9] br[9] wl[27] gnd reram_bitcell_7
Xbit_r28_c9 bl[9] br[9] wl[28] gnd reram_bitcell_7
Xbit_r29_c9 bl[9] br[9] wl[29] gnd reram_bitcell_7
Xbit_r30_c9 bl[9] br[9] wl[30] gnd reram_bitcell_7
Xbit_r31_c9 bl[9] br[9] wl[31] gnd reram_bitcell_7
Xbit_r0_c10 bl[10] br[10] wl[0] gnd reram_bitcell_7
Xbit_r1_c10 bl[10] br[10] wl[1] gnd reram_bitcell_7
Xbit_r2_c10 bl[10] br[10] wl[2] gnd reram_bitcell_7
Xbit_r3_c10 bl[10] br[10] wl[3] gnd reram_bitcell_7
Xbit_r4_c10 bl[10] br[10] wl[4] gnd reram_bitcell_7
Xbit_r5_c10 bl[10] br[10] wl[5] gnd reram_bitcell_7
Xbit_r6_c10 bl[10] br[10] wl[6] gnd reram_bitcell_7
Xbit_r7_c10 bl[10] br[10] wl[7] gnd reram_bitcell_7
Xbit_r8_c10 bl[10] br[10] wl[8] gnd reram_bitcell_7
Xbit_r9_c10 bl[10] br[10] wl[9] gnd reram_bitcell_7
Xbit_r10_c10 bl[10] br[10] wl[10] gnd reram_bitcell_7
Xbit_r11_c10 bl[10] br[10] wl[11] gnd reram_bitcell_7
Xbit_r12_c10 bl[10] br[10] wl[12] gnd reram_bitcell_7
Xbit_r13_c10 bl[10] br[10] wl[13] gnd reram_bitcell_7
Xbit_r14_c10 bl[10] br[10] wl[14] gnd reram_bitcell_7
Xbit_r15_c10 bl[10] br[10] wl[15] gnd reram_bitcell_7
Xbit_r16_c10 bl[10] br[10] wl[16] gnd reram_bitcell_7
Xbit_r17_c10 bl[10] br[10] wl[17] gnd reram_bitcell_7
Xbit_r18_c10 bl[10] br[10] wl[18] gnd reram_bitcell_7
Xbit_r19_c10 bl[10] br[10] wl[19] gnd reram_bitcell_7
Xbit_r20_c10 bl[10] br[10] wl[20] gnd reram_bitcell_7
Xbit_r21_c10 bl[10] br[10] wl[21] gnd reram_bitcell_7
Xbit_r22_c10 bl[10] br[10] wl[22] gnd reram_bitcell_7
Xbit_r23_c10 bl[10] br[10] wl[23] gnd reram_bitcell_7
Xbit_r24_c10 bl[10] br[10] wl[24] gnd reram_bitcell_7
Xbit_r25_c10 bl[10] br[10] wl[25] gnd reram_bitcell_7
Xbit_r26_c10 bl[10] br[10] wl[26] gnd reram_bitcell_7
Xbit_r27_c10 bl[10] br[10] wl[27] gnd reram_bitcell_7
Xbit_r28_c10 bl[10] br[10] wl[28] gnd reram_bitcell_7
Xbit_r29_c10 bl[10] br[10] wl[29] gnd reram_bitcell_7
Xbit_r30_c10 bl[10] br[10] wl[30] gnd reram_bitcell_7
Xbit_r31_c10 bl[10] br[10] wl[31] gnd reram_bitcell_7
Xbit_r0_c11 bl[11] br[11] wl[0] gnd reram_bitcell_7
Xbit_r1_c11 bl[11] br[11] wl[1] gnd reram_bitcell_7
Xbit_r2_c11 bl[11] br[11] wl[2] gnd reram_bitcell_7
Xbit_r3_c11 bl[11] br[11] wl[3] gnd reram_bitcell_7
Xbit_r4_c11 bl[11] br[11] wl[4] gnd reram_bitcell_7
Xbit_r5_c11 bl[11] br[11] wl[5] gnd reram_bitcell_7
Xbit_r6_c11 bl[11] br[11] wl[6] gnd reram_bitcell_7
Xbit_r7_c11 bl[11] br[11] wl[7] gnd reram_bitcell_7
Xbit_r8_c11 bl[11] br[11] wl[8] gnd reram_bitcell_7
Xbit_r9_c11 bl[11] br[11] wl[9] gnd reram_bitcell_7
Xbit_r10_c11 bl[11] br[11] wl[10] gnd reram_bitcell_7
Xbit_r11_c11 bl[11] br[11] wl[11] gnd reram_bitcell_7
Xbit_r12_c11 bl[11] br[11] wl[12] gnd reram_bitcell_7
Xbit_r13_c11 bl[11] br[11] wl[13] gnd reram_bitcell_7
Xbit_r14_c11 bl[11] br[11] wl[14] gnd reram_bitcell_7
Xbit_r15_c11 bl[11] br[11] wl[15] gnd reram_bitcell_7
Xbit_r16_c11 bl[11] br[11] wl[16] gnd reram_bitcell_7
Xbit_r17_c11 bl[11] br[11] wl[17] gnd reram_bitcell_7
Xbit_r18_c11 bl[11] br[11] wl[18] gnd reram_bitcell_7
Xbit_r19_c11 bl[11] br[11] wl[19] gnd reram_bitcell_7
Xbit_r20_c11 bl[11] br[11] wl[20] gnd reram_bitcell_7
Xbit_r21_c11 bl[11] br[11] wl[21] gnd reram_bitcell_7
Xbit_r22_c11 bl[11] br[11] wl[22] gnd reram_bitcell_7
Xbit_r23_c11 bl[11] br[11] wl[23] gnd reram_bitcell_7
Xbit_r24_c11 bl[11] br[11] wl[24] gnd reram_bitcell_7
Xbit_r25_c11 bl[11] br[11] wl[25] gnd reram_bitcell_7
Xbit_r26_c11 bl[11] br[11] wl[26] gnd reram_bitcell_7
Xbit_r27_c11 bl[11] br[11] wl[27] gnd reram_bitcell_7
Xbit_r28_c11 bl[11] br[11] wl[28] gnd reram_bitcell_7
Xbit_r29_c11 bl[11] br[11] wl[29] gnd reram_bitcell_7
Xbit_r30_c11 bl[11] br[11] wl[30] gnd reram_bitcell_7
Xbit_r31_c11 bl[11] br[11] wl[31] gnd reram_bitcell_7
Xbit_r0_c12 bl[12] br[12] wl[0] gnd reram_bitcell_7
Xbit_r1_c12 bl[12] br[12] wl[1] gnd reram_bitcell_7
Xbit_r2_c12 bl[12] br[12] wl[2] gnd reram_bitcell_7
Xbit_r3_c12 bl[12] br[12] wl[3] gnd reram_bitcell_7
Xbit_r4_c12 bl[12] br[12] wl[4] gnd reram_bitcell_7
Xbit_r5_c12 bl[12] br[12] wl[5] gnd reram_bitcell_7
Xbit_r6_c12 bl[12] br[12] wl[6] gnd reram_bitcell_7
Xbit_r7_c12 bl[12] br[12] wl[7] gnd reram_bitcell_7
Xbit_r8_c12 bl[12] br[12] wl[8] gnd reram_bitcell_7
Xbit_r9_c12 bl[12] br[12] wl[9] gnd reram_bitcell_7
Xbit_r10_c12 bl[12] br[12] wl[10] gnd reram_bitcell_7
Xbit_r11_c12 bl[12] br[12] wl[11] gnd reram_bitcell_7
Xbit_r12_c12 bl[12] br[12] wl[12] gnd reram_bitcell_7
Xbit_r13_c12 bl[12] br[12] wl[13] gnd reram_bitcell_7
Xbit_r14_c12 bl[12] br[12] wl[14] gnd reram_bitcell_7
Xbit_r15_c12 bl[12] br[12] wl[15] gnd reram_bitcell_7
Xbit_r16_c12 bl[12] br[12] wl[16] gnd reram_bitcell_7
Xbit_r17_c12 bl[12] br[12] wl[17] gnd reram_bitcell_7
Xbit_r18_c12 bl[12] br[12] wl[18] gnd reram_bitcell_7
Xbit_r19_c12 bl[12] br[12] wl[19] gnd reram_bitcell_7
Xbit_r20_c12 bl[12] br[12] wl[20] gnd reram_bitcell_7
Xbit_r21_c12 bl[12] br[12] wl[21] gnd reram_bitcell_7
Xbit_r22_c12 bl[12] br[12] wl[22] gnd reram_bitcell_7
Xbit_r23_c12 bl[12] br[12] wl[23] gnd reram_bitcell_7
Xbit_r24_c12 bl[12] br[12] wl[24] gnd reram_bitcell_7
Xbit_r25_c12 bl[12] br[12] wl[25] gnd reram_bitcell_7
Xbit_r26_c12 bl[12] br[12] wl[26] gnd reram_bitcell_7
Xbit_r27_c12 bl[12] br[12] wl[27] gnd reram_bitcell_7
Xbit_r28_c12 bl[12] br[12] wl[28] gnd reram_bitcell_7
Xbit_r29_c12 bl[12] br[12] wl[29] gnd reram_bitcell_7
Xbit_r30_c12 bl[12] br[12] wl[30] gnd reram_bitcell_7
Xbit_r31_c12 bl[12] br[12] wl[31] gnd reram_bitcell_7
Xbit_r0_c13 bl[13] br[13] wl[0] gnd reram_bitcell_7
Xbit_r1_c13 bl[13] br[13] wl[1] gnd reram_bitcell_7
Xbit_r2_c13 bl[13] br[13] wl[2] gnd reram_bitcell_7
Xbit_r3_c13 bl[13] br[13] wl[3] gnd reram_bitcell_7
Xbit_r4_c13 bl[13] br[13] wl[4] gnd reram_bitcell_7
Xbit_r5_c13 bl[13] br[13] wl[5] gnd reram_bitcell_7
Xbit_r6_c13 bl[13] br[13] wl[6] gnd reram_bitcell_7
Xbit_r7_c13 bl[13] br[13] wl[7] gnd reram_bitcell_7
Xbit_r8_c13 bl[13] br[13] wl[8] gnd reram_bitcell_7
Xbit_r9_c13 bl[13] br[13] wl[9] gnd reram_bitcell_7
Xbit_r10_c13 bl[13] br[13] wl[10] gnd reram_bitcell_7
Xbit_r11_c13 bl[13] br[13] wl[11] gnd reram_bitcell_7
Xbit_r12_c13 bl[13] br[13] wl[12] gnd reram_bitcell_7
Xbit_r13_c13 bl[13] br[13] wl[13] gnd reram_bitcell_7
Xbit_r14_c13 bl[13] br[13] wl[14] gnd reram_bitcell_7
Xbit_r15_c13 bl[13] br[13] wl[15] gnd reram_bitcell_7
Xbit_r16_c13 bl[13] br[13] wl[16] gnd reram_bitcell_7
Xbit_r17_c13 bl[13] br[13] wl[17] gnd reram_bitcell_7
Xbit_r18_c13 bl[13] br[13] wl[18] gnd reram_bitcell_7
Xbit_r19_c13 bl[13] br[13] wl[19] gnd reram_bitcell_7
Xbit_r20_c13 bl[13] br[13] wl[20] gnd reram_bitcell_7
Xbit_r21_c13 bl[13] br[13] wl[21] gnd reram_bitcell_7
Xbit_r22_c13 bl[13] br[13] wl[22] gnd reram_bitcell_7
Xbit_r23_c13 bl[13] br[13] wl[23] gnd reram_bitcell_7
Xbit_r24_c13 bl[13] br[13] wl[24] gnd reram_bitcell_7
Xbit_r25_c13 bl[13] br[13] wl[25] gnd reram_bitcell_7
Xbit_r26_c13 bl[13] br[13] wl[26] gnd reram_bitcell_7
Xbit_r27_c13 bl[13] br[13] wl[27] gnd reram_bitcell_7
Xbit_r28_c13 bl[13] br[13] wl[28] gnd reram_bitcell_7
Xbit_r29_c13 bl[13] br[13] wl[29] gnd reram_bitcell_7
Xbit_r30_c13 bl[13] br[13] wl[30] gnd reram_bitcell_7
Xbit_r31_c13 bl[13] br[13] wl[31] gnd reram_bitcell_7
Xbit_r0_c14 bl[14] br[14] wl[0] gnd reram_bitcell_7
Xbit_r1_c14 bl[14] br[14] wl[1] gnd reram_bitcell_7
Xbit_r2_c14 bl[14] br[14] wl[2] gnd reram_bitcell_7
Xbit_r3_c14 bl[14] br[14] wl[3] gnd reram_bitcell_7
Xbit_r4_c14 bl[14] br[14] wl[4] gnd reram_bitcell_7
Xbit_r5_c14 bl[14] br[14] wl[5] gnd reram_bitcell_7
Xbit_r6_c14 bl[14] br[14] wl[6] gnd reram_bitcell_7
Xbit_r7_c14 bl[14] br[14] wl[7] gnd reram_bitcell_7
Xbit_r8_c14 bl[14] br[14] wl[8] gnd reram_bitcell_7
Xbit_r9_c14 bl[14] br[14] wl[9] gnd reram_bitcell_7
Xbit_r10_c14 bl[14] br[14] wl[10] gnd reram_bitcell_7
Xbit_r11_c14 bl[14] br[14] wl[11] gnd reram_bitcell_7
Xbit_r12_c14 bl[14] br[14] wl[12] gnd reram_bitcell_7
Xbit_r13_c14 bl[14] br[14] wl[13] gnd reram_bitcell_7
Xbit_r14_c14 bl[14] br[14] wl[14] gnd reram_bitcell_7
Xbit_r15_c14 bl[14] br[14] wl[15] gnd reram_bitcell_7
Xbit_r16_c14 bl[14] br[14] wl[16] gnd reram_bitcell_7
Xbit_r17_c14 bl[14] br[14] wl[17] gnd reram_bitcell_7
Xbit_r18_c14 bl[14] br[14] wl[18] gnd reram_bitcell_7
Xbit_r19_c14 bl[14] br[14] wl[19] gnd reram_bitcell_7
Xbit_r20_c14 bl[14] br[14] wl[20] gnd reram_bitcell_7
Xbit_r21_c14 bl[14] br[14] wl[21] gnd reram_bitcell_7
Xbit_r22_c14 bl[14] br[14] wl[22] gnd reram_bitcell_7
Xbit_r23_c14 bl[14] br[14] wl[23] gnd reram_bitcell_7
Xbit_r24_c14 bl[14] br[14] wl[24] gnd reram_bitcell_7
Xbit_r25_c14 bl[14] br[14] wl[25] gnd reram_bitcell_7
Xbit_r26_c14 bl[14] br[14] wl[26] gnd reram_bitcell_7
Xbit_r27_c14 bl[14] br[14] wl[27] gnd reram_bitcell_7
Xbit_r28_c14 bl[14] br[14] wl[28] gnd reram_bitcell_7
Xbit_r29_c14 bl[14] br[14] wl[29] gnd reram_bitcell_7
Xbit_r30_c14 bl[14] br[14] wl[30] gnd reram_bitcell_7
Xbit_r31_c14 bl[14] br[14] wl[31] gnd reram_bitcell_7
Xbit_r0_c15 bl[15] br[15] wl[0] gnd reram_bitcell_7
Xbit_r1_c15 bl[15] br[15] wl[1] gnd reram_bitcell_7
Xbit_r2_c15 bl[15] br[15] wl[2] gnd reram_bitcell_7
Xbit_r3_c15 bl[15] br[15] wl[3] gnd reram_bitcell_7
Xbit_r4_c15 bl[15] br[15] wl[4] gnd reram_bitcell_7
Xbit_r5_c15 bl[15] br[15] wl[5] gnd reram_bitcell_7
Xbit_r6_c15 bl[15] br[15] wl[6] gnd reram_bitcell_7
Xbit_r7_c15 bl[15] br[15] wl[7] gnd reram_bitcell_7
Xbit_r8_c15 bl[15] br[15] wl[8] gnd reram_bitcell_7
Xbit_r9_c15 bl[15] br[15] wl[9] gnd reram_bitcell_7
Xbit_r10_c15 bl[15] br[15] wl[10] gnd reram_bitcell_7
Xbit_r11_c15 bl[15] br[15] wl[11] gnd reram_bitcell_7
Xbit_r12_c15 bl[15] br[15] wl[12] gnd reram_bitcell_7
Xbit_r13_c15 bl[15] br[15] wl[13] gnd reram_bitcell_7
Xbit_r14_c15 bl[15] br[15] wl[14] gnd reram_bitcell_7
Xbit_r15_c15 bl[15] br[15] wl[15] gnd reram_bitcell_7
Xbit_r16_c15 bl[15] br[15] wl[16] gnd reram_bitcell_7
Xbit_r17_c15 bl[15] br[15] wl[17] gnd reram_bitcell_7
Xbit_r18_c15 bl[15] br[15] wl[18] gnd reram_bitcell_7
Xbit_r19_c15 bl[15] br[15] wl[19] gnd reram_bitcell_7
Xbit_r20_c15 bl[15] br[15] wl[20] gnd reram_bitcell_7
Xbit_r21_c15 bl[15] br[15] wl[21] gnd reram_bitcell_7
Xbit_r22_c15 bl[15] br[15] wl[22] gnd reram_bitcell_7
Xbit_r23_c15 bl[15] br[15] wl[23] gnd reram_bitcell_7
Xbit_r24_c15 bl[15] br[15] wl[24] gnd reram_bitcell_7
Xbit_r25_c15 bl[15] br[15] wl[25] gnd reram_bitcell_7
Xbit_r26_c15 bl[15] br[15] wl[26] gnd reram_bitcell_7
Xbit_r27_c15 bl[15] br[15] wl[27] gnd reram_bitcell_7
Xbit_r28_c15 bl[15] br[15] wl[28] gnd reram_bitcell_7
Xbit_r29_c15 bl[15] br[15] wl[29] gnd reram_bitcell_7
Xbit_r30_c15 bl[15] br[15] wl[30] gnd reram_bitcell_7
Xbit_r31_c15 bl[15] br[15] wl[31] gnd reram_bitcell_7
Xbit_r0_c16 bl[16] br[16] wl[0] gnd reram_bitcell_7
Xbit_r1_c16 bl[16] br[16] wl[1] gnd reram_bitcell_7
Xbit_r2_c16 bl[16] br[16] wl[2] gnd reram_bitcell_7
Xbit_r3_c16 bl[16] br[16] wl[3] gnd reram_bitcell_7
Xbit_r4_c16 bl[16] br[16] wl[4] gnd reram_bitcell_7
Xbit_r5_c16 bl[16] br[16] wl[5] gnd reram_bitcell_7
Xbit_r6_c16 bl[16] br[16] wl[6] gnd reram_bitcell_7
Xbit_r7_c16 bl[16] br[16] wl[7] gnd reram_bitcell_7
Xbit_r8_c16 bl[16] br[16] wl[8] gnd reram_bitcell_7
Xbit_r9_c16 bl[16] br[16] wl[9] gnd reram_bitcell_7
Xbit_r10_c16 bl[16] br[16] wl[10] gnd reram_bitcell_7
Xbit_r11_c16 bl[16] br[16] wl[11] gnd reram_bitcell_7
Xbit_r12_c16 bl[16] br[16] wl[12] gnd reram_bitcell_7
Xbit_r13_c16 bl[16] br[16] wl[13] gnd reram_bitcell_7
Xbit_r14_c16 bl[16] br[16] wl[14] gnd reram_bitcell_7
Xbit_r15_c16 bl[16] br[16] wl[15] gnd reram_bitcell_7
Xbit_r16_c16 bl[16] br[16] wl[16] gnd reram_bitcell_7
Xbit_r17_c16 bl[16] br[16] wl[17] gnd reram_bitcell_7
Xbit_r18_c16 bl[16] br[16] wl[18] gnd reram_bitcell_7
Xbit_r19_c16 bl[16] br[16] wl[19] gnd reram_bitcell_7
Xbit_r20_c16 bl[16] br[16] wl[20] gnd reram_bitcell_7
Xbit_r21_c16 bl[16] br[16] wl[21] gnd reram_bitcell_7
Xbit_r22_c16 bl[16] br[16] wl[22] gnd reram_bitcell_7
Xbit_r23_c16 bl[16] br[16] wl[23] gnd reram_bitcell_7
Xbit_r24_c16 bl[16] br[16] wl[24] gnd reram_bitcell_7
Xbit_r25_c16 bl[16] br[16] wl[25] gnd reram_bitcell_7
Xbit_r26_c16 bl[16] br[16] wl[26] gnd reram_bitcell_7
Xbit_r27_c16 bl[16] br[16] wl[27] gnd reram_bitcell_7
Xbit_r28_c16 bl[16] br[16] wl[28] gnd reram_bitcell_7
Xbit_r29_c16 bl[16] br[16] wl[29] gnd reram_bitcell_7
Xbit_r30_c16 bl[16] br[16] wl[30] gnd reram_bitcell_7
Xbit_r31_c16 bl[16] br[16] wl[31] gnd reram_bitcell_7
Xbit_r0_c17 bl[17] br[17] wl[0] gnd reram_bitcell_7
Xbit_r1_c17 bl[17] br[17] wl[1] gnd reram_bitcell_7
Xbit_r2_c17 bl[17] br[17] wl[2] gnd reram_bitcell_7
Xbit_r3_c17 bl[17] br[17] wl[3] gnd reram_bitcell_7
Xbit_r4_c17 bl[17] br[17] wl[4] gnd reram_bitcell_7
Xbit_r5_c17 bl[17] br[17] wl[5] gnd reram_bitcell_7
Xbit_r6_c17 bl[17] br[17] wl[6] gnd reram_bitcell_7
Xbit_r7_c17 bl[17] br[17] wl[7] gnd reram_bitcell_7
Xbit_r8_c17 bl[17] br[17] wl[8] gnd reram_bitcell_7
Xbit_r9_c17 bl[17] br[17] wl[9] gnd reram_bitcell_7
Xbit_r10_c17 bl[17] br[17] wl[10] gnd reram_bitcell_7
Xbit_r11_c17 bl[17] br[17] wl[11] gnd reram_bitcell_7
Xbit_r12_c17 bl[17] br[17] wl[12] gnd reram_bitcell_7
Xbit_r13_c17 bl[17] br[17] wl[13] gnd reram_bitcell_7
Xbit_r14_c17 bl[17] br[17] wl[14] gnd reram_bitcell_7
Xbit_r15_c17 bl[17] br[17] wl[15] gnd reram_bitcell_7
Xbit_r16_c17 bl[17] br[17] wl[16] gnd reram_bitcell_7
Xbit_r17_c17 bl[17] br[17] wl[17] gnd reram_bitcell_7
Xbit_r18_c17 bl[17] br[17] wl[18] gnd reram_bitcell_7
Xbit_r19_c17 bl[17] br[17] wl[19] gnd reram_bitcell_7
Xbit_r20_c17 bl[17] br[17] wl[20] gnd reram_bitcell_7
Xbit_r21_c17 bl[17] br[17] wl[21] gnd reram_bitcell_7
Xbit_r22_c17 bl[17] br[17] wl[22] gnd reram_bitcell_7
Xbit_r23_c17 bl[17] br[17] wl[23] gnd reram_bitcell_7
Xbit_r24_c17 bl[17] br[17] wl[24] gnd reram_bitcell_7
Xbit_r25_c17 bl[17] br[17] wl[25] gnd reram_bitcell_7
Xbit_r26_c17 bl[17] br[17] wl[26] gnd reram_bitcell_7
Xbit_r27_c17 bl[17] br[17] wl[27] gnd reram_bitcell_7
Xbit_r28_c17 bl[17] br[17] wl[28] gnd reram_bitcell_7
Xbit_r29_c17 bl[17] br[17] wl[29] gnd reram_bitcell_7
Xbit_r30_c17 bl[17] br[17] wl[30] gnd reram_bitcell_7
Xbit_r31_c17 bl[17] br[17] wl[31] gnd reram_bitcell_7
Xbit_r0_c18 bl[18] br[18] wl[0] gnd reram_bitcell_7
Xbit_r1_c18 bl[18] br[18] wl[1] gnd reram_bitcell_7
Xbit_r2_c18 bl[18] br[18] wl[2] gnd reram_bitcell_7
Xbit_r3_c18 bl[18] br[18] wl[3] gnd reram_bitcell_7
Xbit_r4_c18 bl[18] br[18] wl[4] gnd reram_bitcell_7
Xbit_r5_c18 bl[18] br[18] wl[5] gnd reram_bitcell_7
Xbit_r6_c18 bl[18] br[18] wl[6] gnd reram_bitcell_7
Xbit_r7_c18 bl[18] br[18] wl[7] gnd reram_bitcell_7
Xbit_r8_c18 bl[18] br[18] wl[8] gnd reram_bitcell_7
Xbit_r9_c18 bl[18] br[18] wl[9] gnd reram_bitcell_7
Xbit_r10_c18 bl[18] br[18] wl[10] gnd reram_bitcell_7
Xbit_r11_c18 bl[18] br[18] wl[11] gnd reram_bitcell_7
Xbit_r12_c18 bl[18] br[18] wl[12] gnd reram_bitcell_7
Xbit_r13_c18 bl[18] br[18] wl[13] gnd reram_bitcell_7
Xbit_r14_c18 bl[18] br[18] wl[14] gnd reram_bitcell_7
Xbit_r15_c18 bl[18] br[18] wl[15] gnd reram_bitcell_7
Xbit_r16_c18 bl[18] br[18] wl[16] gnd reram_bitcell_7
Xbit_r17_c18 bl[18] br[18] wl[17] gnd reram_bitcell_7
Xbit_r18_c18 bl[18] br[18] wl[18] gnd reram_bitcell_7
Xbit_r19_c18 bl[18] br[18] wl[19] gnd reram_bitcell_7
Xbit_r20_c18 bl[18] br[18] wl[20] gnd reram_bitcell_7
Xbit_r21_c18 bl[18] br[18] wl[21] gnd reram_bitcell_7
Xbit_r22_c18 bl[18] br[18] wl[22] gnd reram_bitcell_7
Xbit_r23_c18 bl[18] br[18] wl[23] gnd reram_bitcell_7
Xbit_r24_c18 bl[18] br[18] wl[24] gnd reram_bitcell_7
Xbit_r25_c18 bl[18] br[18] wl[25] gnd reram_bitcell_7
Xbit_r26_c18 bl[18] br[18] wl[26] gnd reram_bitcell_7
Xbit_r27_c18 bl[18] br[18] wl[27] gnd reram_bitcell_7
Xbit_r28_c18 bl[18] br[18] wl[28] gnd reram_bitcell_7
Xbit_r29_c18 bl[18] br[18] wl[29] gnd reram_bitcell_7
Xbit_r30_c18 bl[18] br[18] wl[30] gnd reram_bitcell_7
Xbit_r31_c18 bl[18] br[18] wl[31] gnd reram_bitcell_7
Xbit_r0_c19 bl[19] br[19] wl[0] gnd reram_bitcell_7
Xbit_r1_c19 bl[19] br[19] wl[1] gnd reram_bitcell_7
Xbit_r2_c19 bl[19] br[19] wl[2] gnd reram_bitcell_7
Xbit_r3_c19 bl[19] br[19] wl[3] gnd reram_bitcell_7
Xbit_r4_c19 bl[19] br[19] wl[4] gnd reram_bitcell_7
Xbit_r5_c19 bl[19] br[19] wl[5] gnd reram_bitcell_7
Xbit_r6_c19 bl[19] br[19] wl[6] gnd reram_bitcell_7
Xbit_r7_c19 bl[19] br[19] wl[7] gnd reram_bitcell_7
Xbit_r8_c19 bl[19] br[19] wl[8] gnd reram_bitcell_7
Xbit_r9_c19 bl[19] br[19] wl[9] gnd reram_bitcell_7
Xbit_r10_c19 bl[19] br[19] wl[10] gnd reram_bitcell_7
Xbit_r11_c19 bl[19] br[19] wl[11] gnd reram_bitcell_7
Xbit_r12_c19 bl[19] br[19] wl[12] gnd reram_bitcell_7
Xbit_r13_c19 bl[19] br[19] wl[13] gnd reram_bitcell_7
Xbit_r14_c19 bl[19] br[19] wl[14] gnd reram_bitcell_7
Xbit_r15_c19 bl[19] br[19] wl[15] gnd reram_bitcell_7
Xbit_r16_c19 bl[19] br[19] wl[16] gnd reram_bitcell_7
Xbit_r17_c19 bl[19] br[19] wl[17] gnd reram_bitcell_7
Xbit_r18_c19 bl[19] br[19] wl[18] gnd reram_bitcell_7
Xbit_r19_c19 bl[19] br[19] wl[19] gnd reram_bitcell_7
Xbit_r20_c19 bl[19] br[19] wl[20] gnd reram_bitcell_7
Xbit_r21_c19 bl[19] br[19] wl[21] gnd reram_bitcell_7
Xbit_r22_c19 bl[19] br[19] wl[22] gnd reram_bitcell_7
Xbit_r23_c19 bl[19] br[19] wl[23] gnd reram_bitcell_7
Xbit_r24_c19 bl[19] br[19] wl[24] gnd reram_bitcell_7
Xbit_r25_c19 bl[19] br[19] wl[25] gnd reram_bitcell_7
Xbit_r26_c19 bl[19] br[19] wl[26] gnd reram_bitcell_7
Xbit_r27_c19 bl[19] br[19] wl[27] gnd reram_bitcell_7
Xbit_r28_c19 bl[19] br[19] wl[28] gnd reram_bitcell_7
Xbit_r29_c19 bl[19] br[19] wl[29] gnd reram_bitcell_7
Xbit_r30_c19 bl[19] br[19] wl[30] gnd reram_bitcell_7
Xbit_r31_c19 bl[19] br[19] wl[31] gnd reram_bitcell_7
Xbit_r0_c20 bl[20] br[20] wl[0] gnd reram_bitcell_7
Xbit_r1_c20 bl[20] br[20] wl[1] gnd reram_bitcell_7
Xbit_r2_c20 bl[20] br[20] wl[2] gnd reram_bitcell_7
Xbit_r3_c20 bl[20] br[20] wl[3] gnd reram_bitcell_7
Xbit_r4_c20 bl[20] br[20] wl[4] gnd reram_bitcell_7
Xbit_r5_c20 bl[20] br[20] wl[5] gnd reram_bitcell_7
Xbit_r6_c20 bl[20] br[20] wl[6] gnd reram_bitcell_7
Xbit_r7_c20 bl[20] br[20] wl[7] gnd reram_bitcell_7
Xbit_r8_c20 bl[20] br[20] wl[8] gnd reram_bitcell_7
Xbit_r9_c20 bl[20] br[20] wl[9] gnd reram_bitcell_7
Xbit_r10_c20 bl[20] br[20] wl[10] gnd reram_bitcell_7
Xbit_r11_c20 bl[20] br[20] wl[11] gnd reram_bitcell_7
Xbit_r12_c20 bl[20] br[20] wl[12] gnd reram_bitcell_7
Xbit_r13_c20 bl[20] br[20] wl[13] gnd reram_bitcell_7
Xbit_r14_c20 bl[20] br[20] wl[14] gnd reram_bitcell_7
Xbit_r15_c20 bl[20] br[20] wl[15] gnd reram_bitcell_7
Xbit_r16_c20 bl[20] br[20] wl[16] gnd reram_bitcell_7
Xbit_r17_c20 bl[20] br[20] wl[17] gnd reram_bitcell_7
Xbit_r18_c20 bl[20] br[20] wl[18] gnd reram_bitcell_7
Xbit_r19_c20 bl[20] br[20] wl[19] gnd reram_bitcell_7
Xbit_r20_c20 bl[20] br[20] wl[20] gnd reram_bitcell_7
Xbit_r21_c20 bl[20] br[20] wl[21] gnd reram_bitcell_7
Xbit_r22_c20 bl[20] br[20] wl[22] gnd reram_bitcell_7
Xbit_r23_c20 bl[20] br[20] wl[23] gnd reram_bitcell_7
Xbit_r24_c20 bl[20] br[20] wl[24] gnd reram_bitcell_7
Xbit_r25_c20 bl[20] br[20] wl[25] gnd reram_bitcell_7
Xbit_r26_c20 bl[20] br[20] wl[26] gnd reram_bitcell_7
Xbit_r27_c20 bl[20] br[20] wl[27] gnd reram_bitcell_7
Xbit_r28_c20 bl[20] br[20] wl[28] gnd reram_bitcell_7
Xbit_r29_c20 bl[20] br[20] wl[29] gnd reram_bitcell_7
Xbit_r30_c20 bl[20] br[20] wl[30] gnd reram_bitcell_7
Xbit_r31_c20 bl[20] br[20] wl[31] gnd reram_bitcell_7
Xbit_r0_c21 bl[21] br[21] wl[0] gnd reram_bitcell_7
Xbit_r1_c21 bl[21] br[21] wl[1] gnd reram_bitcell_7
Xbit_r2_c21 bl[21] br[21] wl[2] gnd reram_bitcell_7
Xbit_r3_c21 bl[21] br[21] wl[3] gnd reram_bitcell_7
Xbit_r4_c21 bl[21] br[21] wl[4] gnd reram_bitcell_7
Xbit_r5_c21 bl[21] br[21] wl[5] gnd reram_bitcell_7
Xbit_r6_c21 bl[21] br[21] wl[6] gnd reram_bitcell_7
Xbit_r7_c21 bl[21] br[21] wl[7] gnd reram_bitcell_7
Xbit_r8_c21 bl[21] br[21] wl[8] gnd reram_bitcell_7
Xbit_r9_c21 bl[21] br[21] wl[9] gnd reram_bitcell_7
Xbit_r10_c21 bl[21] br[21] wl[10] gnd reram_bitcell_7
Xbit_r11_c21 bl[21] br[21] wl[11] gnd reram_bitcell_7
Xbit_r12_c21 bl[21] br[21] wl[12] gnd reram_bitcell_7
Xbit_r13_c21 bl[21] br[21] wl[13] gnd reram_bitcell_7
Xbit_r14_c21 bl[21] br[21] wl[14] gnd reram_bitcell_7
Xbit_r15_c21 bl[21] br[21] wl[15] gnd reram_bitcell_7
Xbit_r16_c21 bl[21] br[21] wl[16] gnd reram_bitcell_7
Xbit_r17_c21 bl[21] br[21] wl[17] gnd reram_bitcell_7
Xbit_r18_c21 bl[21] br[21] wl[18] gnd reram_bitcell_7
Xbit_r19_c21 bl[21] br[21] wl[19] gnd reram_bitcell_7
Xbit_r20_c21 bl[21] br[21] wl[20] gnd reram_bitcell_7
Xbit_r21_c21 bl[21] br[21] wl[21] gnd reram_bitcell_7
Xbit_r22_c21 bl[21] br[21] wl[22] gnd reram_bitcell_7
Xbit_r23_c21 bl[21] br[21] wl[23] gnd reram_bitcell_7
Xbit_r24_c21 bl[21] br[21] wl[24] gnd reram_bitcell_7
Xbit_r25_c21 bl[21] br[21] wl[25] gnd reram_bitcell_7
Xbit_r26_c21 bl[21] br[21] wl[26] gnd reram_bitcell_7
Xbit_r27_c21 bl[21] br[21] wl[27] gnd reram_bitcell_7
Xbit_r28_c21 bl[21] br[21] wl[28] gnd reram_bitcell_7
Xbit_r29_c21 bl[21] br[21] wl[29] gnd reram_bitcell_7
Xbit_r30_c21 bl[21] br[21] wl[30] gnd reram_bitcell_7
Xbit_r31_c21 bl[21] br[21] wl[31] gnd reram_bitcell_7
Xbit_r0_c22 bl[22] br[22] wl[0] gnd reram_bitcell_7
Xbit_r1_c22 bl[22] br[22] wl[1] gnd reram_bitcell_7
Xbit_r2_c22 bl[22] br[22] wl[2] gnd reram_bitcell_7
Xbit_r3_c22 bl[22] br[22] wl[3] gnd reram_bitcell_7
Xbit_r4_c22 bl[22] br[22] wl[4] gnd reram_bitcell_7
Xbit_r5_c22 bl[22] br[22] wl[5] gnd reram_bitcell_7
Xbit_r6_c22 bl[22] br[22] wl[6] gnd reram_bitcell_7
Xbit_r7_c22 bl[22] br[22] wl[7] gnd reram_bitcell_7
Xbit_r8_c22 bl[22] br[22] wl[8] gnd reram_bitcell_7
Xbit_r9_c22 bl[22] br[22] wl[9] gnd reram_bitcell_7
Xbit_r10_c22 bl[22] br[22] wl[10] gnd reram_bitcell_7
Xbit_r11_c22 bl[22] br[22] wl[11] gnd reram_bitcell_7
Xbit_r12_c22 bl[22] br[22] wl[12] gnd reram_bitcell_7
Xbit_r13_c22 bl[22] br[22] wl[13] gnd reram_bitcell_7
Xbit_r14_c22 bl[22] br[22] wl[14] gnd reram_bitcell_7
Xbit_r15_c22 bl[22] br[22] wl[15] gnd reram_bitcell_7
Xbit_r16_c22 bl[22] br[22] wl[16] gnd reram_bitcell_7
Xbit_r17_c22 bl[22] br[22] wl[17] gnd reram_bitcell_7
Xbit_r18_c22 bl[22] br[22] wl[18] gnd reram_bitcell_7
Xbit_r19_c22 bl[22] br[22] wl[19] gnd reram_bitcell_7
Xbit_r20_c22 bl[22] br[22] wl[20] gnd reram_bitcell_7
Xbit_r21_c22 bl[22] br[22] wl[21] gnd reram_bitcell_7
Xbit_r22_c22 bl[22] br[22] wl[22] gnd reram_bitcell_7
Xbit_r23_c22 bl[22] br[22] wl[23] gnd reram_bitcell_7
Xbit_r24_c22 bl[22] br[22] wl[24] gnd reram_bitcell_7
Xbit_r25_c22 bl[22] br[22] wl[25] gnd reram_bitcell_7
Xbit_r26_c22 bl[22] br[22] wl[26] gnd reram_bitcell_7
Xbit_r27_c22 bl[22] br[22] wl[27] gnd reram_bitcell_7
Xbit_r28_c22 bl[22] br[22] wl[28] gnd reram_bitcell_7
Xbit_r29_c22 bl[22] br[22] wl[29] gnd reram_bitcell_7
Xbit_r30_c22 bl[22] br[22] wl[30] gnd reram_bitcell_7
Xbit_r31_c22 bl[22] br[22] wl[31] gnd reram_bitcell_7
Xbit_r0_c23 bl[23] br[23] wl[0] gnd reram_bitcell_7
Xbit_r1_c23 bl[23] br[23] wl[1] gnd reram_bitcell_7
Xbit_r2_c23 bl[23] br[23] wl[2] gnd reram_bitcell_7
Xbit_r3_c23 bl[23] br[23] wl[3] gnd reram_bitcell_7
Xbit_r4_c23 bl[23] br[23] wl[4] gnd reram_bitcell_7
Xbit_r5_c23 bl[23] br[23] wl[5] gnd reram_bitcell_7
Xbit_r6_c23 bl[23] br[23] wl[6] gnd reram_bitcell_7
Xbit_r7_c23 bl[23] br[23] wl[7] gnd reram_bitcell_7
Xbit_r8_c23 bl[23] br[23] wl[8] gnd reram_bitcell_7
Xbit_r9_c23 bl[23] br[23] wl[9] gnd reram_bitcell_7
Xbit_r10_c23 bl[23] br[23] wl[10] gnd reram_bitcell_7
Xbit_r11_c23 bl[23] br[23] wl[11] gnd reram_bitcell_7
Xbit_r12_c23 bl[23] br[23] wl[12] gnd reram_bitcell_7
Xbit_r13_c23 bl[23] br[23] wl[13] gnd reram_bitcell_7
Xbit_r14_c23 bl[23] br[23] wl[14] gnd reram_bitcell_7
Xbit_r15_c23 bl[23] br[23] wl[15] gnd reram_bitcell_7
Xbit_r16_c23 bl[23] br[23] wl[16] gnd reram_bitcell_7
Xbit_r17_c23 bl[23] br[23] wl[17] gnd reram_bitcell_7
Xbit_r18_c23 bl[23] br[23] wl[18] gnd reram_bitcell_7
Xbit_r19_c23 bl[23] br[23] wl[19] gnd reram_bitcell_7
Xbit_r20_c23 bl[23] br[23] wl[20] gnd reram_bitcell_7
Xbit_r21_c23 bl[23] br[23] wl[21] gnd reram_bitcell_7
Xbit_r22_c23 bl[23] br[23] wl[22] gnd reram_bitcell_7
Xbit_r23_c23 bl[23] br[23] wl[23] gnd reram_bitcell_7
Xbit_r24_c23 bl[23] br[23] wl[24] gnd reram_bitcell_7
Xbit_r25_c23 bl[23] br[23] wl[25] gnd reram_bitcell_7
Xbit_r26_c23 bl[23] br[23] wl[26] gnd reram_bitcell_7
Xbit_r27_c23 bl[23] br[23] wl[27] gnd reram_bitcell_7
Xbit_r28_c23 bl[23] br[23] wl[28] gnd reram_bitcell_7
Xbit_r29_c23 bl[23] br[23] wl[29] gnd reram_bitcell_7
Xbit_r30_c23 bl[23] br[23] wl[30] gnd reram_bitcell_7
Xbit_r31_c23 bl[23] br[23] wl[31] gnd reram_bitcell_7
Xbit_r0_c24 bl[24] br[24] wl[0] gnd reram_bitcell_7
Xbit_r1_c24 bl[24] br[24] wl[1] gnd reram_bitcell_7
Xbit_r2_c24 bl[24] br[24] wl[2] gnd reram_bitcell_7
Xbit_r3_c24 bl[24] br[24] wl[3] gnd reram_bitcell_7
Xbit_r4_c24 bl[24] br[24] wl[4] gnd reram_bitcell_7
Xbit_r5_c24 bl[24] br[24] wl[5] gnd reram_bitcell_7
Xbit_r6_c24 bl[24] br[24] wl[6] gnd reram_bitcell_7
Xbit_r7_c24 bl[24] br[24] wl[7] gnd reram_bitcell_7
Xbit_r8_c24 bl[24] br[24] wl[8] gnd reram_bitcell_7
Xbit_r9_c24 bl[24] br[24] wl[9] gnd reram_bitcell_7
Xbit_r10_c24 bl[24] br[24] wl[10] gnd reram_bitcell_7
Xbit_r11_c24 bl[24] br[24] wl[11] gnd reram_bitcell_7
Xbit_r12_c24 bl[24] br[24] wl[12] gnd reram_bitcell_7
Xbit_r13_c24 bl[24] br[24] wl[13] gnd reram_bitcell_7
Xbit_r14_c24 bl[24] br[24] wl[14] gnd reram_bitcell_7
Xbit_r15_c24 bl[24] br[24] wl[15] gnd reram_bitcell_7
Xbit_r16_c24 bl[24] br[24] wl[16] gnd reram_bitcell_7
Xbit_r17_c24 bl[24] br[24] wl[17] gnd reram_bitcell_7
Xbit_r18_c24 bl[24] br[24] wl[18] gnd reram_bitcell_7
Xbit_r19_c24 bl[24] br[24] wl[19] gnd reram_bitcell_7
Xbit_r20_c24 bl[24] br[24] wl[20] gnd reram_bitcell_7
Xbit_r21_c24 bl[24] br[24] wl[21] gnd reram_bitcell_7
Xbit_r22_c24 bl[24] br[24] wl[22] gnd reram_bitcell_7
Xbit_r23_c24 bl[24] br[24] wl[23] gnd reram_bitcell_7
Xbit_r24_c24 bl[24] br[24] wl[24] gnd reram_bitcell_7
Xbit_r25_c24 bl[24] br[24] wl[25] gnd reram_bitcell_7
Xbit_r26_c24 bl[24] br[24] wl[26] gnd reram_bitcell_7
Xbit_r27_c24 bl[24] br[24] wl[27] gnd reram_bitcell_7
Xbit_r28_c24 bl[24] br[24] wl[28] gnd reram_bitcell_7
Xbit_r29_c24 bl[24] br[24] wl[29] gnd reram_bitcell_7
Xbit_r30_c24 bl[24] br[24] wl[30] gnd reram_bitcell_7
Xbit_r31_c24 bl[24] br[24] wl[31] gnd reram_bitcell_7
Xbit_r0_c25 bl[25] br[25] wl[0] gnd reram_bitcell_7
Xbit_r1_c25 bl[25] br[25] wl[1] gnd reram_bitcell_7
Xbit_r2_c25 bl[25] br[25] wl[2] gnd reram_bitcell_7
Xbit_r3_c25 bl[25] br[25] wl[3] gnd reram_bitcell_7
Xbit_r4_c25 bl[25] br[25] wl[4] gnd reram_bitcell_7
Xbit_r5_c25 bl[25] br[25] wl[5] gnd reram_bitcell_7
Xbit_r6_c25 bl[25] br[25] wl[6] gnd reram_bitcell_7
Xbit_r7_c25 bl[25] br[25] wl[7] gnd reram_bitcell_7
Xbit_r8_c25 bl[25] br[25] wl[8] gnd reram_bitcell_7
Xbit_r9_c25 bl[25] br[25] wl[9] gnd reram_bitcell_7
Xbit_r10_c25 bl[25] br[25] wl[10] gnd reram_bitcell_7
Xbit_r11_c25 bl[25] br[25] wl[11] gnd reram_bitcell_7
Xbit_r12_c25 bl[25] br[25] wl[12] gnd reram_bitcell_7
Xbit_r13_c25 bl[25] br[25] wl[13] gnd reram_bitcell_7
Xbit_r14_c25 bl[25] br[25] wl[14] gnd reram_bitcell_7
Xbit_r15_c25 bl[25] br[25] wl[15] gnd reram_bitcell_7
Xbit_r16_c25 bl[25] br[25] wl[16] gnd reram_bitcell_7
Xbit_r17_c25 bl[25] br[25] wl[17] gnd reram_bitcell_7
Xbit_r18_c25 bl[25] br[25] wl[18] gnd reram_bitcell_7
Xbit_r19_c25 bl[25] br[25] wl[19] gnd reram_bitcell_7
Xbit_r20_c25 bl[25] br[25] wl[20] gnd reram_bitcell_7
Xbit_r21_c25 bl[25] br[25] wl[21] gnd reram_bitcell_7
Xbit_r22_c25 bl[25] br[25] wl[22] gnd reram_bitcell_7
Xbit_r23_c25 bl[25] br[25] wl[23] gnd reram_bitcell_7
Xbit_r24_c25 bl[25] br[25] wl[24] gnd reram_bitcell_7
Xbit_r25_c25 bl[25] br[25] wl[25] gnd reram_bitcell_7
Xbit_r26_c25 bl[25] br[25] wl[26] gnd reram_bitcell_7
Xbit_r27_c25 bl[25] br[25] wl[27] gnd reram_bitcell_7
Xbit_r28_c25 bl[25] br[25] wl[28] gnd reram_bitcell_7
Xbit_r29_c25 bl[25] br[25] wl[29] gnd reram_bitcell_7
Xbit_r30_c25 bl[25] br[25] wl[30] gnd reram_bitcell_7
Xbit_r31_c25 bl[25] br[25] wl[31] gnd reram_bitcell_7
Xbit_r0_c26 bl[26] br[26] wl[0] gnd reram_bitcell_7
Xbit_r1_c26 bl[26] br[26] wl[1] gnd reram_bitcell_7
Xbit_r2_c26 bl[26] br[26] wl[2] gnd reram_bitcell_7
Xbit_r3_c26 bl[26] br[26] wl[3] gnd reram_bitcell_7
Xbit_r4_c26 bl[26] br[26] wl[4] gnd reram_bitcell_7
Xbit_r5_c26 bl[26] br[26] wl[5] gnd reram_bitcell_7
Xbit_r6_c26 bl[26] br[26] wl[6] gnd reram_bitcell_7
Xbit_r7_c26 bl[26] br[26] wl[7] gnd reram_bitcell_7
Xbit_r8_c26 bl[26] br[26] wl[8] gnd reram_bitcell_7
Xbit_r9_c26 bl[26] br[26] wl[9] gnd reram_bitcell_7
Xbit_r10_c26 bl[26] br[26] wl[10] gnd reram_bitcell_7
Xbit_r11_c26 bl[26] br[26] wl[11] gnd reram_bitcell_7
Xbit_r12_c26 bl[26] br[26] wl[12] gnd reram_bitcell_7
Xbit_r13_c26 bl[26] br[26] wl[13] gnd reram_bitcell_7
Xbit_r14_c26 bl[26] br[26] wl[14] gnd reram_bitcell_7
Xbit_r15_c26 bl[26] br[26] wl[15] gnd reram_bitcell_7
Xbit_r16_c26 bl[26] br[26] wl[16] gnd reram_bitcell_7
Xbit_r17_c26 bl[26] br[26] wl[17] gnd reram_bitcell_7
Xbit_r18_c26 bl[26] br[26] wl[18] gnd reram_bitcell_7
Xbit_r19_c26 bl[26] br[26] wl[19] gnd reram_bitcell_7
Xbit_r20_c26 bl[26] br[26] wl[20] gnd reram_bitcell_7
Xbit_r21_c26 bl[26] br[26] wl[21] gnd reram_bitcell_7
Xbit_r22_c26 bl[26] br[26] wl[22] gnd reram_bitcell_7
Xbit_r23_c26 bl[26] br[26] wl[23] gnd reram_bitcell_7
Xbit_r24_c26 bl[26] br[26] wl[24] gnd reram_bitcell_7
Xbit_r25_c26 bl[26] br[26] wl[25] gnd reram_bitcell_7
Xbit_r26_c26 bl[26] br[26] wl[26] gnd reram_bitcell_7
Xbit_r27_c26 bl[26] br[26] wl[27] gnd reram_bitcell_7
Xbit_r28_c26 bl[26] br[26] wl[28] gnd reram_bitcell_7
Xbit_r29_c26 bl[26] br[26] wl[29] gnd reram_bitcell_7
Xbit_r30_c26 bl[26] br[26] wl[30] gnd reram_bitcell_7
Xbit_r31_c26 bl[26] br[26] wl[31] gnd reram_bitcell_7
Xbit_r0_c27 bl[27] br[27] wl[0] gnd reram_bitcell_7
Xbit_r1_c27 bl[27] br[27] wl[1] gnd reram_bitcell_7
Xbit_r2_c27 bl[27] br[27] wl[2] gnd reram_bitcell_7
Xbit_r3_c27 bl[27] br[27] wl[3] gnd reram_bitcell_7
Xbit_r4_c27 bl[27] br[27] wl[4] gnd reram_bitcell_7
Xbit_r5_c27 bl[27] br[27] wl[5] gnd reram_bitcell_7
Xbit_r6_c27 bl[27] br[27] wl[6] gnd reram_bitcell_7
Xbit_r7_c27 bl[27] br[27] wl[7] gnd reram_bitcell_7
Xbit_r8_c27 bl[27] br[27] wl[8] gnd reram_bitcell_7
Xbit_r9_c27 bl[27] br[27] wl[9] gnd reram_bitcell_7
Xbit_r10_c27 bl[27] br[27] wl[10] gnd reram_bitcell_7
Xbit_r11_c27 bl[27] br[27] wl[11] gnd reram_bitcell_7
Xbit_r12_c27 bl[27] br[27] wl[12] gnd reram_bitcell_7
Xbit_r13_c27 bl[27] br[27] wl[13] gnd reram_bitcell_7
Xbit_r14_c27 bl[27] br[27] wl[14] gnd reram_bitcell_7
Xbit_r15_c27 bl[27] br[27] wl[15] gnd reram_bitcell_7
Xbit_r16_c27 bl[27] br[27] wl[16] gnd reram_bitcell_7
Xbit_r17_c27 bl[27] br[27] wl[17] gnd reram_bitcell_7
Xbit_r18_c27 bl[27] br[27] wl[18] gnd reram_bitcell_7
Xbit_r19_c27 bl[27] br[27] wl[19] gnd reram_bitcell_7
Xbit_r20_c27 bl[27] br[27] wl[20] gnd reram_bitcell_7
Xbit_r21_c27 bl[27] br[27] wl[21] gnd reram_bitcell_7
Xbit_r22_c27 bl[27] br[27] wl[22] gnd reram_bitcell_7
Xbit_r23_c27 bl[27] br[27] wl[23] gnd reram_bitcell_7
Xbit_r24_c27 bl[27] br[27] wl[24] gnd reram_bitcell_7
Xbit_r25_c27 bl[27] br[27] wl[25] gnd reram_bitcell_7
Xbit_r26_c27 bl[27] br[27] wl[26] gnd reram_bitcell_7
Xbit_r27_c27 bl[27] br[27] wl[27] gnd reram_bitcell_7
Xbit_r28_c27 bl[27] br[27] wl[28] gnd reram_bitcell_7
Xbit_r29_c27 bl[27] br[27] wl[29] gnd reram_bitcell_7
Xbit_r30_c27 bl[27] br[27] wl[30] gnd reram_bitcell_7
Xbit_r31_c27 bl[27] br[27] wl[31] gnd reram_bitcell_7
Xbit_r0_c28 bl[28] br[28] wl[0] gnd reram_bitcell_7
Xbit_r1_c28 bl[28] br[28] wl[1] gnd reram_bitcell_7
Xbit_r2_c28 bl[28] br[28] wl[2] gnd reram_bitcell_7
Xbit_r3_c28 bl[28] br[28] wl[3] gnd reram_bitcell_7
Xbit_r4_c28 bl[28] br[28] wl[4] gnd reram_bitcell_7
Xbit_r5_c28 bl[28] br[28] wl[5] gnd reram_bitcell_7
Xbit_r6_c28 bl[28] br[28] wl[6] gnd reram_bitcell_7
Xbit_r7_c28 bl[28] br[28] wl[7] gnd reram_bitcell_7
Xbit_r8_c28 bl[28] br[28] wl[8] gnd reram_bitcell_7
Xbit_r9_c28 bl[28] br[28] wl[9] gnd reram_bitcell_7
Xbit_r10_c28 bl[28] br[28] wl[10] gnd reram_bitcell_7
Xbit_r11_c28 bl[28] br[28] wl[11] gnd reram_bitcell_7
Xbit_r12_c28 bl[28] br[28] wl[12] gnd reram_bitcell_7
Xbit_r13_c28 bl[28] br[28] wl[13] gnd reram_bitcell_7
Xbit_r14_c28 bl[28] br[28] wl[14] gnd reram_bitcell_7
Xbit_r15_c28 bl[28] br[28] wl[15] gnd reram_bitcell_7
Xbit_r16_c28 bl[28] br[28] wl[16] gnd reram_bitcell_7
Xbit_r17_c28 bl[28] br[28] wl[17] gnd reram_bitcell_7
Xbit_r18_c28 bl[28] br[28] wl[18] gnd reram_bitcell_7
Xbit_r19_c28 bl[28] br[28] wl[19] gnd reram_bitcell_7
Xbit_r20_c28 bl[28] br[28] wl[20] gnd reram_bitcell_7
Xbit_r21_c28 bl[28] br[28] wl[21] gnd reram_bitcell_7
Xbit_r22_c28 bl[28] br[28] wl[22] gnd reram_bitcell_7
Xbit_r23_c28 bl[28] br[28] wl[23] gnd reram_bitcell_7
Xbit_r24_c28 bl[28] br[28] wl[24] gnd reram_bitcell_7
Xbit_r25_c28 bl[28] br[28] wl[25] gnd reram_bitcell_7
Xbit_r26_c28 bl[28] br[28] wl[26] gnd reram_bitcell_7
Xbit_r27_c28 bl[28] br[28] wl[27] gnd reram_bitcell_7
Xbit_r28_c28 bl[28] br[28] wl[28] gnd reram_bitcell_7
Xbit_r29_c28 bl[28] br[28] wl[29] gnd reram_bitcell_7
Xbit_r30_c28 bl[28] br[28] wl[30] gnd reram_bitcell_7
Xbit_r31_c28 bl[28] br[28] wl[31] gnd reram_bitcell_7
Xbit_r0_c29 bl[29] br[29] wl[0] gnd reram_bitcell_7
Xbit_r1_c29 bl[29] br[29] wl[1] gnd reram_bitcell_7
Xbit_r2_c29 bl[29] br[29] wl[2] gnd reram_bitcell_7
Xbit_r3_c29 bl[29] br[29] wl[3] gnd reram_bitcell_7
Xbit_r4_c29 bl[29] br[29] wl[4] gnd reram_bitcell_7
Xbit_r5_c29 bl[29] br[29] wl[5] gnd reram_bitcell_7
Xbit_r6_c29 bl[29] br[29] wl[6] gnd reram_bitcell_7
Xbit_r7_c29 bl[29] br[29] wl[7] gnd reram_bitcell_7
Xbit_r8_c29 bl[29] br[29] wl[8] gnd reram_bitcell_7
Xbit_r9_c29 bl[29] br[29] wl[9] gnd reram_bitcell_7
Xbit_r10_c29 bl[29] br[29] wl[10] gnd reram_bitcell_7
Xbit_r11_c29 bl[29] br[29] wl[11] gnd reram_bitcell_7
Xbit_r12_c29 bl[29] br[29] wl[12] gnd reram_bitcell_7
Xbit_r13_c29 bl[29] br[29] wl[13] gnd reram_bitcell_7
Xbit_r14_c29 bl[29] br[29] wl[14] gnd reram_bitcell_7
Xbit_r15_c29 bl[29] br[29] wl[15] gnd reram_bitcell_7
Xbit_r16_c29 bl[29] br[29] wl[16] gnd reram_bitcell_7
Xbit_r17_c29 bl[29] br[29] wl[17] gnd reram_bitcell_7
Xbit_r18_c29 bl[29] br[29] wl[18] gnd reram_bitcell_7
Xbit_r19_c29 bl[29] br[29] wl[19] gnd reram_bitcell_7
Xbit_r20_c29 bl[29] br[29] wl[20] gnd reram_bitcell_7
Xbit_r21_c29 bl[29] br[29] wl[21] gnd reram_bitcell_7
Xbit_r22_c29 bl[29] br[29] wl[22] gnd reram_bitcell_7
Xbit_r23_c29 bl[29] br[29] wl[23] gnd reram_bitcell_7
Xbit_r24_c29 bl[29] br[29] wl[24] gnd reram_bitcell_7
Xbit_r25_c29 bl[29] br[29] wl[25] gnd reram_bitcell_7
Xbit_r26_c29 bl[29] br[29] wl[26] gnd reram_bitcell_7
Xbit_r27_c29 bl[29] br[29] wl[27] gnd reram_bitcell_7
Xbit_r28_c29 bl[29] br[29] wl[28] gnd reram_bitcell_7
Xbit_r29_c29 bl[29] br[29] wl[29] gnd reram_bitcell_7
Xbit_r30_c29 bl[29] br[29] wl[30] gnd reram_bitcell_7
Xbit_r31_c29 bl[29] br[29] wl[31] gnd reram_bitcell_7
Xbit_r0_c30 bl[30] br[30] wl[0] gnd reram_bitcell_7
Xbit_r1_c30 bl[30] br[30] wl[1] gnd reram_bitcell_7
Xbit_r2_c30 bl[30] br[30] wl[2] gnd reram_bitcell_7
Xbit_r3_c30 bl[30] br[30] wl[3] gnd reram_bitcell_7
Xbit_r4_c30 bl[30] br[30] wl[4] gnd reram_bitcell_7
Xbit_r5_c30 bl[30] br[30] wl[5] gnd reram_bitcell_7
Xbit_r6_c30 bl[30] br[30] wl[6] gnd reram_bitcell_7
Xbit_r7_c30 bl[30] br[30] wl[7] gnd reram_bitcell_7
Xbit_r8_c30 bl[30] br[30] wl[8] gnd reram_bitcell_7
Xbit_r9_c30 bl[30] br[30] wl[9] gnd reram_bitcell_7
Xbit_r10_c30 bl[30] br[30] wl[10] gnd reram_bitcell_7
Xbit_r11_c30 bl[30] br[30] wl[11] gnd reram_bitcell_7
Xbit_r12_c30 bl[30] br[30] wl[12] gnd reram_bitcell_7
Xbit_r13_c30 bl[30] br[30] wl[13] gnd reram_bitcell_7
Xbit_r14_c30 bl[30] br[30] wl[14] gnd reram_bitcell_7
Xbit_r15_c30 bl[30] br[30] wl[15] gnd reram_bitcell_7
Xbit_r16_c30 bl[30] br[30] wl[16] gnd reram_bitcell_7
Xbit_r17_c30 bl[30] br[30] wl[17] gnd reram_bitcell_7
Xbit_r18_c30 bl[30] br[30] wl[18] gnd reram_bitcell_7
Xbit_r19_c30 bl[30] br[30] wl[19] gnd reram_bitcell_7
Xbit_r20_c30 bl[30] br[30] wl[20] gnd reram_bitcell_7
Xbit_r21_c30 bl[30] br[30] wl[21] gnd reram_bitcell_7
Xbit_r22_c30 bl[30] br[30] wl[22] gnd reram_bitcell_7
Xbit_r23_c30 bl[30] br[30] wl[23] gnd reram_bitcell_7
Xbit_r24_c30 bl[30] br[30] wl[24] gnd reram_bitcell_7
Xbit_r25_c30 bl[30] br[30] wl[25] gnd reram_bitcell_7
Xbit_r26_c30 bl[30] br[30] wl[26] gnd reram_bitcell_7
Xbit_r27_c30 bl[30] br[30] wl[27] gnd reram_bitcell_7
Xbit_r28_c30 bl[30] br[30] wl[28] gnd reram_bitcell_7
Xbit_r29_c30 bl[30] br[30] wl[29] gnd reram_bitcell_7
Xbit_r30_c30 bl[30] br[30] wl[30] gnd reram_bitcell_7
Xbit_r31_c30 bl[30] br[30] wl[31] gnd reram_bitcell_7
Xbit_r0_c31 bl[31] br[31] wl[0] gnd reram_bitcell_7
Xbit_r1_c31 bl[31] br[31] wl[1] gnd reram_bitcell_7
Xbit_r2_c31 bl[31] br[31] wl[2] gnd reram_bitcell_7
Xbit_r3_c31 bl[31] br[31] wl[3] gnd reram_bitcell_7
Xbit_r4_c31 bl[31] br[31] wl[4] gnd reram_bitcell_7
Xbit_r5_c31 bl[31] br[31] wl[5] gnd reram_bitcell_7
Xbit_r6_c31 bl[31] br[31] wl[6] gnd reram_bitcell_7
Xbit_r7_c31 bl[31] br[31] wl[7] gnd reram_bitcell_7
Xbit_r8_c31 bl[31] br[31] wl[8] gnd reram_bitcell_7
Xbit_r9_c31 bl[31] br[31] wl[9] gnd reram_bitcell_7
Xbit_r10_c31 bl[31] br[31] wl[10] gnd reram_bitcell_7
Xbit_r11_c31 bl[31] br[31] wl[11] gnd reram_bitcell_7
Xbit_r12_c31 bl[31] br[31] wl[12] gnd reram_bitcell_7
Xbit_r13_c31 bl[31] br[31] wl[13] gnd reram_bitcell_7
Xbit_r14_c31 bl[31] br[31] wl[14] gnd reram_bitcell_7
Xbit_r15_c31 bl[31] br[31] wl[15] gnd reram_bitcell_7
Xbit_r16_c31 bl[31] br[31] wl[16] gnd reram_bitcell_7
Xbit_r17_c31 bl[31] br[31] wl[17] gnd reram_bitcell_7
Xbit_r18_c31 bl[31] br[31] wl[18] gnd reram_bitcell_7
Xbit_r19_c31 bl[31] br[31] wl[19] gnd reram_bitcell_7
Xbit_r20_c31 bl[31] br[31] wl[20] gnd reram_bitcell_7
Xbit_r21_c31 bl[31] br[31] wl[21] gnd reram_bitcell_7
Xbit_r22_c31 bl[31] br[31] wl[22] gnd reram_bitcell_7
Xbit_r23_c31 bl[31] br[31] wl[23] gnd reram_bitcell_7
Xbit_r24_c31 bl[31] br[31] wl[24] gnd reram_bitcell_7
Xbit_r25_c31 bl[31] br[31] wl[25] gnd reram_bitcell_7
Xbit_r26_c31 bl[31] br[31] wl[26] gnd reram_bitcell_7
Xbit_r27_c31 bl[31] br[31] wl[27] gnd reram_bitcell_7
Xbit_r28_c31 bl[31] br[31] wl[28] gnd reram_bitcell_7
Xbit_r29_c31 bl[31] br[31] wl[29] gnd reram_bitcell_7
Xbit_r30_c31 bl[31] br[31] wl[30] gnd reram_bitcell_7
Xbit_r31_c31 bl[31] br[31] wl[31] gnd reram_bitcell_7
Xbit_r0_c32 bl[32] br[32] wl[0] gnd reram_bitcell_7
Xbit_r1_c32 bl[32] br[32] wl[1] gnd reram_bitcell_7
Xbit_r2_c32 bl[32] br[32] wl[2] gnd reram_bitcell_7
Xbit_r3_c32 bl[32] br[32] wl[3] gnd reram_bitcell_7
Xbit_r4_c32 bl[32] br[32] wl[4] gnd reram_bitcell_7
Xbit_r5_c32 bl[32] br[32] wl[5] gnd reram_bitcell_7
Xbit_r6_c32 bl[32] br[32] wl[6] gnd reram_bitcell_7
Xbit_r7_c32 bl[32] br[32] wl[7] gnd reram_bitcell_7
Xbit_r8_c32 bl[32] br[32] wl[8] gnd reram_bitcell_7
Xbit_r9_c32 bl[32] br[32] wl[9] gnd reram_bitcell_7
Xbit_r10_c32 bl[32] br[32] wl[10] gnd reram_bitcell_7
Xbit_r11_c32 bl[32] br[32] wl[11] gnd reram_bitcell_7
Xbit_r12_c32 bl[32] br[32] wl[12] gnd reram_bitcell_7
Xbit_r13_c32 bl[32] br[32] wl[13] gnd reram_bitcell_7
Xbit_r14_c32 bl[32] br[32] wl[14] gnd reram_bitcell_7
Xbit_r15_c32 bl[32] br[32] wl[15] gnd reram_bitcell_7
Xbit_r16_c32 bl[32] br[32] wl[16] gnd reram_bitcell_7
Xbit_r17_c32 bl[32] br[32] wl[17] gnd reram_bitcell_7
Xbit_r18_c32 bl[32] br[32] wl[18] gnd reram_bitcell_7
Xbit_r19_c32 bl[32] br[32] wl[19] gnd reram_bitcell_7
Xbit_r20_c32 bl[32] br[32] wl[20] gnd reram_bitcell_7
Xbit_r21_c32 bl[32] br[32] wl[21] gnd reram_bitcell_7
Xbit_r22_c32 bl[32] br[32] wl[22] gnd reram_bitcell_7
Xbit_r23_c32 bl[32] br[32] wl[23] gnd reram_bitcell_7
Xbit_r24_c32 bl[32] br[32] wl[24] gnd reram_bitcell_7
Xbit_r25_c32 bl[32] br[32] wl[25] gnd reram_bitcell_7
Xbit_r26_c32 bl[32] br[32] wl[26] gnd reram_bitcell_7
Xbit_r27_c32 bl[32] br[32] wl[27] gnd reram_bitcell_7
Xbit_r28_c32 bl[32] br[32] wl[28] gnd reram_bitcell_7
Xbit_r29_c32 bl[32] br[32] wl[29] gnd reram_bitcell_7
Xbit_r30_c32 bl[32] br[32] wl[30] gnd reram_bitcell_7
Xbit_r31_c32 bl[32] br[32] wl[31] gnd reram_bitcell_7
Xbit_r0_c33 bl[33] br[33] wl[0] gnd reram_bitcell_7
Xbit_r1_c33 bl[33] br[33] wl[1] gnd reram_bitcell_7
Xbit_r2_c33 bl[33] br[33] wl[2] gnd reram_bitcell_7
Xbit_r3_c33 bl[33] br[33] wl[3] gnd reram_bitcell_7
Xbit_r4_c33 bl[33] br[33] wl[4] gnd reram_bitcell_7
Xbit_r5_c33 bl[33] br[33] wl[5] gnd reram_bitcell_7
Xbit_r6_c33 bl[33] br[33] wl[6] gnd reram_bitcell_7
Xbit_r7_c33 bl[33] br[33] wl[7] gnd reram_bitcell_7
Xbit_r8_c33 bl[33] br[33] wl[8] gnd reram_bitcell_7
Xbit_r9_c33 bl[33] br[33] wl[9] gnd reram_bitcell_7
Xbit_r10_c33 bl[33] br[33] wl[10] gnd reram_bitcell_7
Xbit_r11_c33 bl[33] br[33] wl[11] gnd reram_bitcell_7
Xbit_r12_c33 bl[33] br[33] wl[12] gnd reram_bitcell_7
Xbit_r13_c33 bl[33] br[33] wl[13] gnd reram_bitcell_7
Xbit_r14_c33 bl[33] br[33] wl[14] gnd reram_bitcell_7
Xbit_r15_c33 bl[33] br[33] wl[15] gnd reram_bitcell_7
Xbit_r16_c33 bl[33] br[33] wl[16] gnd reram_bitcell_7
Xbit_r17_c33 bl[33] br[33] wl[17] gnd reram_bitcell_7
Xbit_r18_c33 bl[33] br[33] wl[18] gnd reram_bitcell_7
Xbit_r19_c33 bl[33] br[33] wl[19] gnd reram_bitcell_7
Xbit_r20_c33 bl[33] br[33] wl[20] gnd reram_bitcell_7
Xbit_r21_c33 bl[33] br[33] wl[21] gnd reram_bitcell_7
Xbit_r22_c33 bl[33] br[33] wl[22] gnd reram_bitcell_7
Xbit_r23_c33 bl[33] br[33] wl[23] gnd reram_bitcell_7
Xbit_r24_c33 bl[33] br[33] wl[24] gnd reram_bitcell_7
Xbit_r25_c33 bl[33] br[33] wl[25] gnd reram_bitcell_7
Xbit_r26_c33 bl[33] br[33] wl[26] gnd reram_bitcell_7
Xbit_r27_c33 bl[33] br[33] wl[27] gnd reram_bitcell_7
Xbit_r28_c33 bl[33] br[33] wl[28] gnd reram_bitcell_7
Xbit_r29_c33 bl[33] br[33] wl[29] gnd reram_bitcell_7
Xbit_r30_c33 bl[33] br[33] wl[30] gnd reram_bitcell_7
Xbit_r31_c33 bl[33] br[33] wl[31] gnd reram_bitcell_7
Xbit_r0_c34 bl[34] br[34] wl[0] gnd reram_bitcell_7
Xbit_r1_c34 bl[34] br[34] wl[1] gnd reram_bitcell_7
Xbit_r2_c34 bl[34] br[34] wl[2] gnd reram_bitcell_7
Xbit_r3_c34 bl[34] br[34] wl[3] gnd reram_bitcell_7
Xbit_r4_c34 bl[34] br[34] wl[4] gnd reram_bitcell_7
Xbit_r5_c34 bl[34] br[34] wl[5] gnd reram_bitcell_7
Xbit_r6_c34 bl[34] br[34] wl[6] gnd reram_bitcell_7
Xbit_r7_c34 bl[34] br[34] wl[7] gnd reram_bitcell_7
Xbit_r8_c34 bl[34] br[34] wl[8] gnd reram_bitcell_7
Xbit_r9_c34 bl[34] br[34] wl[9] gnd reram_bitcell_7
Xbit_r10_c34 bl[34] br[34] wl[10] gnd reram_bitcell_7
Xbit_r11_c34 bl[34] br[34] wl[11] gnd reram_bitcell_7
Xbit_r12_c34 bl[34] br[34] wl[12] gnd reram_bitcell_7
Xbit_r13_c34 bl[34] br[34] wl[13] gnd reram_bitcell_7
Xbit_r14_c34 bl[34] br[34] wl[14] gnd reram_bitcell_7
Xbit_r15_c34 bl[34] br[34] wl[15] gnd reram_bitcell_7
Xbit_r16_c34 bl[34] br[34] wl[16] gnd reram_bitcell_7
Xbit_r17_c34 bl[34] br[34] wl[17] gnd reram_bitcell_7
Xbit_r18_c34 bl[34] br[34] wl[18] gnd reram_bitcell_7
Xbit_r19_c34 bl[34] br[34] wl[19] gnd reram_bitcell_7
Xbit_r20_c34 bl[34] br[34] wl[20] gnd reram_bitcell_7
Xbit_r21_c34 bl[34] br[34] wl[21] gnd reram_bitcell_7
Xbit_r22_c34 bl[34] br[34] wl[22] gnd reram_bitcell_7
Xbit_r23_c34 bl[34] br[34] wl[23] gnd reram_bitcell_7
Xbit_r24_c34 bl[34] br[34] wl[24] gnd reram_bitcell_7
Xbit_r25_c34 bl[34] br[34] wl[25] gnd reram_bitcell_7
Xbit_r26_c34 bl[34] br[34] wl[26] gnd reram_bitcell_7
Xbit_r27_c34 bl[34] br[34] wl[27] gnd reram_bitcell_7
Xbit_r28_c34 bl[34] br[34] wl[28] gnd reram_bitcell_7
Xbit_r29_c34 bl[34] br[34] wl[29] gnd reram_bitcell_7
Xbit_r30_c34 bl[34] br[34] wl[30] gnd reram_bitcell_7
Xbit_r31_c34 bl[34] br[34] wl[31] gnd reram_bitcell_7
Xbit_r0_c35 bl[35] br[35] wl[0] gnd reram_bitcell_7
Xbit_r1_c35 bl[35] br[35] wl[1] gnd reram_bitcell_7
Xbit_r2_c35 bl[35] br[35] wl[2] gnd reram_bitcell_7
Xbit_r3_c35 bl[35] br[35] wl[3] gnd reram_bitcell_7
Xbit_r4_c35 bl[35] br[35] wl[4] gnd reram_bitcell_7
Xbit_r5_c35 bl[35] br[35] wl[5] gnd reram_bitcell_7
Xbit_r6_c35 bl[35] br[35] wl[6] gnd reram_bitcell_7
Xbit_r7_c35 bl[35] br[35] wl[7] gnd reram_bitcell_7
Xbit_r8_c35 bl[35] br[35] wl[8] gnd reram_bitcell_7
Xbit_r9_c35 bl[35] br[35] wl[9] gnd reram_bitcell_7
Xbit_r10_c35 bl[35] br[35] wl[10] gnd reram_bitcell_7
Xbit_r11_c35 bl[35] br[35] wl[11] gnd reram_bitcell_7
Xbit_r12_c35 bl[35] br[35] wl[12] gnd reram_bitcell_7
Xbit_r13_c35 bl[35] br[35] wl[13] gnd reram_bitcell_7
Xbit_r14_c35 bl[35] br[35] wl[14] gnd reram_bitcell_7
Xbit_r15_c35 bl[35] br[35] wl[15] gnd reram_bitcell_7
Xbit_r16_c35 bl[35] br[35] wl[16] gnd reram_bitcell_7
Xbit_r17_c35 bl[35] br[35] wl[17] gnd reram_bitcell_7
Xbit_r18_c35 bl[35] br[35] wl[18] gnd reram_bitcell_7
Xbit_r19_c35 bl[35] br[35] wl[19] gnd reram_bitcell_7
Xbit_r20_c35 bl[35] br[35] wl[20] gnd reram_bitcell_7
Xbit_r21_c35 bl[35] br[35] wl[21] gnd reram_bitcell_7
Xbit_r22_c35 bl[35] br[35] wl[22] gnd reram_bitcell_7
Xbit_r23_c35 bl[35] br[35] wl[23] gnd reram_bitcell_7
Xbit_r24_c35 bl[35] br[35] wl[24] gnd reram_bitcell_7
Xbit_r25_c35 bl[35] br[35] wl[25] gnd reram_bitcell_7
Xbit_r26_c35 bl[35] br[35] wl[26] gnd reram_bitcell_7
Xbit_r27_c35 bl[35] br[35] wl[27] gnd reram_bitcell_7
Xbit_r28_c35 bl[35] br[35] wl[28] gnd reram_bitcell_7
Xbit_r29_c35 bl[35] br[35] wl[29] gnd reram_bitcell_7
Xbit_r30_c35 bl[35] br[35] wl[30] gnd reram_bitcell_7
Xbit_r31_c35 bl[35] br[35] wl[31] gnd reram_bitcell_7
Xbit_r0_c36 bl[36] br[36] wl[0] gnd reram_bitcell_7
Xbit_r1_c36 bl[36] br[36] wl[1] gnd reram_bitcell_7
Xbit_r2_c36 bl[36] br[36] wl[2] gnd reram_bitcell_7
Xbit_r3_c36 bl[36] br[36] wl[3] gnd reram_bitcell_7
Xbit_r4_c36 bl[36] br[36] wl[4] gnd reram_bitcell_7
Xbit_r5_c36 bl[36] br[36] wl[5] gnd reram_bitcell_7
Xbit_r6_c36 bl[36] br[36] wl[6] gnd reram_bitcell_7
Xbit_r7_c36 bl[36] br[36] wl[7] gnd reram_bitcell_7
Xbit_r8_c36 bl[36] br[36] wl[8] gnd reram_bitcell_7
Xbit_r9_c36 bl[36] br[36] wl[9] gnd reram_bitcell_7
Xbit_r10_c36 bl[36] br[36] wl[10] gnd reram_bitcell_7
Xbit_r11_c36 bl[36] br[36] wl[11] gnd reram_bitcell_7
Xbit_r12_c36 bl[36] br[36] wl[12] gnd reram_bitcell_7
Xbit_r13_c36 bl[36] br[36] wl[13] gnd reram_bitcell_7
Xbit_r14_c36 bl[36] br[36] wl[14] gnd reram_bitcell_7
Xbit_r15_c36 bl[36] br[36] wl[15] gnd reram_bitcell_7
Xbit_r16_c36 bl[36] br[36] wl[16] gnd reram_bitcell_7
Xbit_r17_c36 bl[36] br[36] wl[17] gnd reram_bitcell_7
Xbit_r18_c36 bl[36] br[36] wl[18] gnd reram_bitcell_7
Xbit_r19_c36 bl[36] br[36] wl[19] gnd reram_bitcell_7
Xbit_r20_c36 bl[36] br[36] wl[20] gnd reram_bitcell_7
Xbit_r21_c36 bl[36] br[36] wl[21] gnd reram_bitcell_7
Xbit_r22_c36 bl[36] br[36] wl[22] gnd reram_bitcell_7
Xbit_r23_c36 bl[36] br[36] wl[23] gnd reram_bitcell_7
Xbit_r24_c36 bl[36] br[36] wl[24] gnd reram_bitcell_7
Xbit_r25_c36 bl[36] br[36] wl[25] gnd reram_bitcell_7
Xbit_r26_c36 bl[36] br[36] wl[26] gnd reram_bitcell_7
Xbit_r27_c36 bl[36] br[36] wl[27] gnd reram_bitcell_7
Xbit_r28_c36 bl[36] br[36] wl[28] gnd reram_bitcell_7
Xbit_r29_c36 bl[36] br[36] wl[29] gnd reram_bitcell_7
Xbit_r30_c36 bl[36] br[36] wl[30] gnd reram_bitcell_7
Xbit_r31_c36 bl[36] br[36] wl[31] gnd reram_bitcell_7
Xbit_r0_c37 bl[37] br[37] wl[0] gnd reram_bitcell_7
Xbit_r1_c37 bl[37] br[37] wl[1] gnd reram_bitcell_7
Xbit_r2_c37 bl[37] br[37] wl[2] gnd reram_bitcell_7
Xbit_r3_c37 bl[37] br[37] wl[3] gnd reram_bitcell_7
Xbit_r4_c37 bl[37] br[37] wl[4] gnd reram_bitcell_7
Xbit_r5_c37 bl[37] br[37] wl[5] gnd reram_bitcell_7
Xbit_r6_c37 bl[37] br[37] wl[6] gnd reram_bitcell_7
Xbit_r7_c37 bl[37] br[37] wl[7] gnd reram_bitcell_7
Xbit_r8_c37 bl[37] br[37] wl[8] gnd reram_bitcell_7
Xbit_r9_c37 bl[37] br[37] wl[9] gnd reram_bitcell_7
Xbit_r10_c37 bl[37] br[37] wl[10] gnd reram_bitcell_7
Xbit_r11_c37 bl[37] br[37] wl[11] gnd reram_bitcell_7
Xbit_r12_c37 bl[37] br[37] wl[12] gnd reram_bitcell_7
Xbit_r13_c37 bl[37] br[37] wl[13] gnd reram_bitcell_7
Xbit_r14_c37 bl[37] br[37] wl[14] gnd reram_bitcell_7
Xbit_r15_c37 bl[37] br[37] wl[15] gnd reram_bitcell_7
Xbit_r16_c37 bl[37] br[37] wl[16] gnd reram_bitcell_7
Xbit_r17_c37 bl[37] br[37] wl[17] gnd reram_bitcell_7
Xbit_r18_c37 bl[37] br[37] wl[18] gnd reram_bitcell_7
Xbit_r19_c37 bl[37] br[37] wl[19] gnd reram_bitcell_7
Xbit_r20_c37 bl[37] br[37] wl[20] gnd reram_bitcell_7
Xbit_r21_c37 bl[37] br[37] wl[21] gnd reram_bitcell_7
Xbit_r22_c37 bl[37] br[37] wl[22] gnd reram_bitcell_7
Xbit_r23_c37 bl[37] br[37] wl[23] gnd reram_bitcell_7
Xbit_r24_c37 bl[37] br[37] wl[24] gnd reram_bitcell_7
Xbit_r25_c37 bl[37] br[37] wl[25] gnd reram_bitcell_7
Xbit_r26_c37 bl[37] br[37] wl[26] gnd reram_bitcell_7
Xbit_r27_c37 bl[37] br[37] wl[27] gnd reram_bitcell_7
Xbit_r28_c37 bl[37] br[37] wl[28] gnd reram_bitcell_7
Xbit_r29_c37 bl[37] br[37] wl[29] gnd reram_bitcell_7
Xbit_r30_c37 bl[37] br[37] wl[30] gnd reram_bitcell_7
Xbit_r31_c37 bl[37] br[37] wl[31] gnd reram_bitcell_7
Xbit_r0_c38 bl[38] br[38] wl[0] gnd reram_bitcell_7
Xbit_r1_c38 bl[38] br[38] wl[1] gnd reram_bitcell_7
Xbit_r2_c38 bl[38] br[38] wl[2] gnd reram_bitcell_7
Xbit_r3_c38 bl[38] br[38] wl[3] gnd reram_bitcell_7
Xbit_r4_c38 bl[38] br[38] wl[4] gnd reram_bitcell_7
Xbit_r5_c38 bl[38] br[38] wl[5] gnd reram_bitcell_7
Xbit_r6_c38 bl[38] br[38] wl[6] gnd reram_bitcell_7
Xbit_r7_c38 bl[38] br[38] wl[7] gnd reram_bitcell_7
Xbit_r8_c38 bl[38] br[38] wl[8] gnd reram_bitcell_7
Xbit_r9_c38 bl[38] br[38] wl[9] gnd reram_bitcell_7
Xbit_r10_c38 bl[38] br[38] wl[10] gnd reram_bitcell_7
Xbit_r11_c38 bl[38] br[38] wl[11] gnd reram_bitcell_7
Xbit_r12_c38 bl[38] br[38] wl[12] gnd reram_bitcell_7
Xbit_r13_c38 bl[38] br[38] wl[13] gnd reram_bitcell_7
Xbit_r14_c38 bl[38] br[38] wl[14] gnd reram_bitcell_7
Xbit_r15_c38 bl[38] br[38] wl[15] gnd reram_bitcell_7
Xbit_r16_c38 bl[38] br[38] wl[16] gnd reram_bitcell_7
Xbit_r17_c38 bl[38] br[38] wl[17] gnd reram_bitcell_7
Xbit_r18_c38 bl[38] br[38] wl[18] gnd reram_bitcell_7
Xbit_r19_c38 bl[38] br[38] wl[19] gnd reram_bitcell_7
Xbit_r20_c38 bl[38] br[38] wl[20] gnd reram_bitcell_7
Xbit_r21_c38 bl[38] br[38] wl[21] gnd reram_bitcell_7
Xbit_r22_c38 bl[38] br[38] wl[22] gnd reram_bitcell_7
Xbit_r23_c38 bl[38] br[38] wl[23] gnd reram_bitcell_7
Xbit_r24_c38 bl[38] br[38] wl[24] gnd reram_bitcell_7
Xbit_r25_c38 bl[38] br[38] wl[25] gnd reram_bitcell_7
Xbit_r26_c38 bl[38] br[38] wl[26] gnd reram_bitcell_7
Xbit_r27_c38 bl[38] br[38] wl[27] gnd reram_bitcell_7
Xbit_r28_c38 bl[38] br[38] wl[28] gnd reram_bitcell_7
Xbit_r29_c38 bl[38] br[38] wl[29] gnd reram_bitcell_7
Xbit_r30_c38 bl[38] br[38] wl[30] gnd reram_bitcell_7
Xbit_r31_c38 bl[38] br[38] wl[31] gnd reram_bitcell_7
Xbit_r0_c39 bl[39] br[39] wl[0] gnd reram_bitcell_7
Xbit_r1_c39 bl[39] br[39] wl[1] gnd reram_bitcell_7
Xbit_r2_c39 bl[39] br[39] wl[2] gnd reram_bitcell_7
Xbit_r3_c39 bl[39] br[39] wl[3] gnd reram_bitcell_7
Xbit_r4_c39 bl[39] br[39] wl[4] gnd reram_bitcell_7
Xbit_r5_c39 bl[39] br[39] wl[5] gnd reram_bitcell_7
Xbit_r6_c39 bl[39] br[39] wl[6] gnd reram_bitcell_7
Xbit_r7_c39 bl[39] br[39] wl[7] gnd reram_bitcell_7
Xbit_r8_c39 bl[39] br[39] wl[8] gnd reram_bitcell_7
Xbit_r9_c39 bl[39] br[39] wl[9] gnd reram_bitcell_7
Xbit_r10_c39 bl[39] br[39] wl[10] gnd reram_bitcell_7
Xbit_r11_c39 bl[39] br[39] wl[11] gnd reram_bitcell_7
Xbit_r12_c39 bl[39] br[39] wl[12] gnd reram_bitcell_7
Xbit_r13_c39 bl[39] br[39] wl[13] gnd reram_bitcell_7
Xbit_r14_c39 bl[39] br[39] wl[14] gnd reram_bitcell_7
Xbit_r15_c39 bl[39] br[39] wl[15] gnd reram_bitcell_7
Xbit_r16_c39 bl[39] br[39] wl[16] gnd reram_bitcell_7
Xbit_r17_c39 bl[39] br[39] wl[17] gnd reram_bitcell_7
Xbit_r18_c39 bl[39] br[39] wl[18] gnd reram_bitcell_7
Xbit_r19_c39 bl[39] br[39] wl[19] gnd reram_bitcell_7
Xbit_r20_c39 bl[39] br[39] wl[20] gnd reram_bitcell_7
Xbit_r21_c39 bl[39] br[39] wl[21] gnd reram_bitcell_7
Xbit_r22_c39 bl[39] br[39] wl[22] gnd reram_bitcell_7
Xbit_r23_c39 bl[39] br[39] wl[23] gnd reram_bitcell_7
Xbit_r24_c39 bl[39] br[39] wl[24] gnd reram_bitcell_7
Xbit_r25_c39 bl[39] br[39] wl[25] gnd reram_bitcell_7
Xbit_r26_c39 bl[39] br[39] wl[26] gnd reram_bitcell_7
Xbit_r27_c39 bl[39] br[39] wl[27] gnd reram_bitcell_7
Xbit_r28_c39 bl[39] br[39] wl[28] gnd reram_bitcell_7
Xbit_r29_c39 bl[39] br[39] wl[29] gnd reram_bitcell_7
Xbit_r30_c39 bl[39] br[39] wl[30] gnd reram_bitcell_7
Xbit_r31_c39 bl[39] br[39] wl[31] gnd reram_bitcell_7
Xbit_r0_c40 bl[40] br[40] wl[0] gnd reram_bitcell_7
Xbit_r1_c40 bl[40] br[40] wl[1] gnd reram_bitcell_7
Xbit_r2_c40 bl[40] br[40] wl[2] gnd reram_bitcell_7
Xbit_r3_c40 bl[40] br[40] wl[3] gnd reram_bitcell_7
Xbit_r4_c40 bl[40] br[40] wl[4] gnd reram_bitcell_7
Xbit_r5_c40 bl[40] br[40] wl[5] gnd reram_bitcell_7
Xbit_r6_c40 bl[40] br[40] wl[6] gnd reram_bitcell_7
Xbit_r7_c40 bl[40] br[40] wl[7] gnd reram_bitcell_7
Xbit_r8_c40 bl[40] br[40] wl[8] gnd reram_bitcell_7
Xbit_r9_c40 bl[40] br[40] wl[9] gnd reram_bitcell_7
Xbit_r10_c40 bl[40] br[40] wl[10] gnd reram_bitcell_7
Xbit_r11_c40 bl[40] br[40] wl[11] gnd reram_bitcell_7
Xbit_r12_c40 bl[40] br[40] wl[12] gnd reram_bitcell_7
Xbit_r13_c40 bl[40] br[40] wl[13] gnd reram_bitcell_7
Xbit_r14_c40 bl[40] br[40] wl[14] gnd reram_bitcell_7
Xbit_r15_c40 bl[40] br[40] wl[15] gnd reram_bitcell_7
Xbit_r16_c40 bl[40] br[40] wl[16] gnd reram_bitcell_7
Xbit_r17_c40 bl[40] br[40] wl[17] gnd reram_bitcell_7
Xbit_r18_c40 bl[40] br[40] wl[18] gnd reram_bitcell_7
Xbit_r19_c40 bl[40] br[40] wl[19] gnd reram_bitcell_7
Xbit_r20_c40 bl[40] br[40] wl[20] gnd reram_bitcell_7
Xbit_r21_c40 bl[40] br[40] wl[21] gnd reram_bitcell_7
Xbit_r22_c40 bl[40] br[40] wl[22] gnd reram_bitcell_7
Xbit_r23_c40 bl[40] br[40] wl[23] gnd reram_bitcell_7
Xbit_r24_c40 bl[40] br[40] wl[24] gnd reram_bitcell_7
Xbit_r25_c40 bl[40] br[40] wl[25] gnd reram_bitcell_7
Xbit_r26_c40 bl[40] br[40] wl[26] gnd reram_bitcell_7
Xbit_r27_c40 bl[40] br[40] wl[27] gnd reram_bitcell_7
Xbit_r28_c40 bl[40] br[40] wl[28] gnd reram_bitcell_7
Xbit_r29_c40 bl[40] br[40] wl[29] gnd reram_bitcell_7
Xbit_r30_c40 bl[40] br[40] wl[30] gnd reram_bitcell_7
Xbit_r31_c40 bl[40] br[40] wl[31] gnd reram_bitcell_7
Xbit_r0_c41 bl[41] br[41] wl[0] gnd reram_bitcell_7
Xbit_r1_c41 bl[41] br[41] wl[1] gnd reram_bitcell_7
Xbit_r2_c41 bl[41] br[41] wl[2] gnd reram_bitcell_7
Xbit_r3_c41 bl[41] br[41] wl[3] gnd reram_bitcell_7
Xbit_r4_c41 bl[41] br[41] wl[4] gnd reram_bitcell_7
Xbit_r5_c41 bl[41] br[41] wl[5] gnd reram_bitcell_7
Xbit_r6_c41 bl[41] br[41] wl[6] gnd reram_bitcell_7
Xbit_r7_c41 bl[41] br[41] wl[7] gnd reram_bitcell_7
Xbit_r8_c41 bl[41] br[41] wl[8] gnd reram_bitcell_7
Xbit_r9_c41 bl[41] br[41] wl[9] gnd reram_bitcell_7
Xbit_r10_c41 bl[41] br[41] wl[10] gnd reram_bitcell_7
Xbit_r11_c41 bl[41] br[41] wl[11] gnd reram_bitcell_7
Xbit_r12_c41 bl[41] br[41] wl[12] gnd reram_bitcell_7
Xbit_r13_c41 bl[41] br[41] wl[13] gnd reram_bitcell_7
Xbit_r14_c41 bl[41] br[41] wl[14] gnd reram_bitcell_7
Xbit_r15_c41 bl[41] br[41] wl[15] gnd reram_bitcell_7
Xbit_r16_c41 bl[41] br[41] wl[16] gnd reram_bitcell_7
Xbit_r17_c41 bl[41] br[41] wl[17] gnd reram_bitcell_7
Xbit_r18_c41 bl[41] br[41] wl[18] gnd reram_bitcell_7
Xbit_r19_c41 bl[41] br[41] wl[19] gnd reram_bitcell_7
Xbit_r20_c41 bl[41] br[41] wl[20] gnd reram_bitcell_7
Xbit_r21_c41 bl[41] br[41] wl[21] gnd reram_bitcell_7
Xbit_r22_c41 bl[41] br[41] wl[22] gnd reram_bitcell_7
Xbit_r23_c41 bl[41] br[41] wl[23] gnd reram_bitcell_7
Xbit_r24_c41 bl[41] br[41] wl[24] gnd reram_bitcell_7
Xbit_r25_c41 bl[41] br[41] wl[25] gnd reram_bitcell_7
Xbit_r26_c41 bl[41] br[41] wl[26] gnd reram_bitcell_7
Xbit_r27_c41 bl[41] br[41] wl[27] gnd reram_bitcell_7
Xbit_r28_c41 bl[41] br[41] wl[28] gnd reram_bitcell_7
Xbit_r29_c41 bl[41] br[41] wl[29] gnd reram_bitcell_7
Xbit_r30_c41 bl[41] br[41] wl[30] gnd reram_bitcell_7
Xbit_r31_c41 bl[41] br[41] wl[31] gnd reram_bitcell_7
Xbit_r0_c42 bl[42] br[42] wl[0] gnd reram_bitcell_7
Xbit_r1_c42 bl[42] br[42] wl[1] gnd reram_bitcell_7
Xbit_r2_c42 bl[42] br[42] wl[2] gnd reram_bitcell_7
Xbit_r3_c42 bl[42] br[42] wl[3] gnd reram_bitcell_7
Xbit_r4_c42 bl[42] br[42] wl[4] gnd reram_bitcell_7
Xbit_r5_c42 bl[42] br[42] wl[5] gnd reram_bitcell_7
Xbit_r6_c42 bl[42] br[42] wl[6] gnd reram_bitcell_7
Xbit_r7_c42 bl[42] br[42] wl[7] gnd reram_bitcell_7
Xbit_r8_c42 bl[42] br[42] wl[8] gnd reram_bitcell_7
Xbit_r9_c42 bl[42] br[42] wl[9] gnd reram_bitcell_7
Xbit_r10_c42 bl[42] br[42] wl[10] gnd reram_bitcell_7
Xbit_r11_c42 bl[42] br[42] wl[11] gnd reram_bitcell_7
Xbit_r12_c42 bl[42] br[42] wl[12] gnd reram_bitcell_7
Xbit_r13_c42 bl[42] br[42] wl[13] gnd reram_bitcell_7
Xbit_r14_c42 bl[42] br[42] wl[14] gnd reram_bitcell_7
Xbit_r15_c42 bl[42] br[42] wl[15] gnd reram_bitcell_7
Xbit_r16_c42 bl[42] br[42] wl[16] gnd reram_bitcell_7
Xbit_r17_c42 bl[42] br[42] wl[17] gnd reram_bitcell_7
Xbit_r18_c42 bl[42] br[42] wl[18] gnd reram_bitcell_7
Xbit_r19_c42 bl[42] br[42] wl[19] gnd reram_bitcell_7
Xbit_r20_c42 bl[42] br[42] wl[20] gnd reram_bitcell_7
Xbit_r21_c42 bl[42] br[42] wl[21] gnd reram_bitcell_7
Xbit_r22_c42 bl[42] br[42] wl[22] gnd reram_bitcell_7
Xbit_r23_c42 bl[42] br[42] wl[23] gnd reram_bitcell_7
Xbit_r24_c42 bl[42] br[42] wl[24] gnd reram_bitcell_7
Xbit_r25_c42 bl[42] br[42] wl[25] gnd reram_bitcell_7
Xbit_r26_c42 bl[42] br[42] wl[26] gnd reram_bitcell_7
Xbit_r27_c42 bl[42] br[42] wl[27] gnd reram_bitcell_7
Xbit_r28_c42 bl[42] br[42] wl[28] gnd reram_bitcell_7
Xbit_r29_c42 bl[42] br[42] wl[29] gnd reram_bitcell_7
Xbit_r30_c42 bl[42] br[42] wl[30] gnd reram_bitcell_7
Xbit_r31_c42 bl[42] br[42] wl[31] gnd reram_bitcell_7
Xbit_r0_c43 bl[43] br[43] wl[0] gnd reram_bitcell_7
Xbit_r1_c43 bl[43] br[43] wl[1] gnd reram_bitcell_7
Xbit_r2_c43 bl[43] br[43] wl[2] gnd reram_bitcell_7
Xbit_r3_c43 bl[43] br[43] wl[3] gnd reram_bitcell_7
Xbit_r4_c43 bl[43] br[43] wl[4] gnd reram_bitcell_7
Xbit_r5_c43 bl[43] br[43] wl[5] gnd reram_bitcell_7
Xbit_r6_c43 bl[43] br[43] wl[6] gnd reram_bitcell_7
Xbit_r7_c43 bl[43] br[43] wl[7] gnd reram_bitcell_7
Xbit_r8_c43 bl[43] br[43] wl[8] gnd reram_bitcell_7
Xbit_r9_c43 bl[43] br[43] wl[9] gnd reram_bitcell_7
Xbit_r10_c43 bl[43] br[43] wl[10] gnd reram_bitcell_7
Xbit_r11_c43 bl[43] br[43] wl[11] gnd reram_bitcell_7
Xbit_r12_c43 bl[43] br[43] wl[12] gnd reram_bitcell_7
Xbit_r13_c43 bl[43] br[43] wl[13] gnd reram_bitcell_7
Xbit_r14_c43 bl[43] br[43] wl[14] gnd reram_bitcell_7
Xbit_r15_c43 bl[43] br[43] wl[15] gnd reram_bitcell_7
Xbit_r16_c43 bl[43] br[43] wl[16] gnd reram_bitcell_7
Xbit_r17_c43 bl[43] br[43] wl[17] gnd reram_bitcell_7
Xbit_r18_c43 bl[43] br[43] wl[18] gnd reram_bitcell_7
Xbit_r19_c43 bl[43] br[43] wl[19] gnd reram_bitcell_7
Xbit_r20_c43 bl[43] br[43] wl[20] gnd reram_bitcell_7
Xbit_r21_c43 bl[43] br[43] wl[21] gnd reram_bitcell_7
Xbit_r22_c43 bl[43] br[43] wl[22] gnd reram_bitcell_7
Xbit_r23_c43 bl[43] br[43] wl[23] gnd reram_bitcell_7
Xbit_r24_c43 bl[43] br[43] wl[24] gnd reram_bitcell_7
Xbit_r25_c43 bl[43] br[43] wl[25] gnd reram_bitcell_7
Xbit_r26_c43 bl[43] br[43] wl[26] gnd reram_bitcell_7
Xbit_r27_c43 bl[43] br[43] wl[27] gnd reram_bitcell_7
Xbit_r28_c43 bl[43] br[43] wl[28] gnd reram_bitcell_7
Xbit_r29_c43 bl[43] br[43] wl[29] gnd reram_bitcell_7
Xbit_r30_c43 bl[43] br[43] wl[30] gnd reram_bitcell_7
Xbit_r31_c43 bl[43] br[43] wl[31] gnd reram_bitcell_7
Xbit_r0_c44 bl[44] br[44] wl[0] gnd reram_bitcell_7
Xbit_r1_c44 bl[44] br[44] wl[1] gnd reram_bitcell_7
Xbit_r2_c44 bl[44] br[44] wl[2] gnd reram_bitcell_7
Xbit_r3_c44 bl[44] br[44] wl[3] gnd reram_bitcell_7
Xbit_r4_c44 bl[44] br[44] wl[4] gnd reram_bitcell_7
Xbit_r5_c44 bl[44] br[44] wl[5] gnd reram_bitcell_7
Xbit_r6_c44 bl[44] br[44] wl[6] gnd reram_bitcell_7
Xbit_r7_c44 bl[44] br[44] wl[7] gnd reram_bitcell_7
Xbit_r8_c44 bl[44] br[44] wl[8] gnd reram_bitcell_7
Xbit_r9_c44 bl[44] br[44] wl[9] gnd reram_bitcell_7
Xbit_r10_c44 bl[44] br[44] wl[10] gnd reram_bitcell_7
Xbit_r11_c44 bl[44] br[44] wl[11] gnd reram_bitcell_7
Xbit_r12_c44 bl[44] br[44] wl[12] gnd reram_bitcell_7
Xbit_r13_c44 bl[44] br[44] wl[13] gnd reram_bitcell_7
Xbit_r14_c44 bl[44] br[44] wl[14] gnd reram_bitcell_7
Xbit_r15_c44 bl[44] br[44] wl[15] gnd reram_bitcell_7
Xbit_r16_c44 bl[44] br[44] wl[16] gnd reram_bitcell_7
Xbit_r17_c44 bl[44] br[44] wl[17] gnd reram_bitcell_7
Xbit_r18_c44 bl[44] br[44] wl[18] gnd reram_bitcell_7
Xbit_r19_c44 bl[44] br[44] wl[19] gnd reram_bitcell_7
Xbit_r20_c44 bl[44] br[44] wl[20] gnd reram_bitcell_7
Xbit_r21_c44 bl[44] br[44] wl[21] gnd reram_bitcell_7
Xbit_r22_c44 bl[44] br[44] wl[22] gnd reram_bitcell_7
Xbit_r23_c44 bl[44] br[44] wl[23] gnd reram_bitcell_7
Xbit_r24_c44 bl[44] br[44] wl[24] gnd reram_bitcell_7
Xbit_r25_c44 bl[44] br[44] wl[25] gnd reram_bitcell_7
Xbit_r26_c44 bl[44] br[44] wl[26] gnd reram_bitcell_7
Xbit_r27_c44 bl[44] br[44] wl[27] gnd reram_bitcell_7
Xbit_r28_c44 bl[44] br[44] wl[28] gnd reram_bitcell_7
Xbit_r29_c44 bl[44] br[44] wl[29] gnd reram_bitcell_7
Xbit_r30_c44 bl[44] br[44] wl[30] gnd reram_bitcell_7
Xbit_r31_c44 bl[44] br[44] wl[31] gnd reram_bitcell_7
Xbit_r0_c45 bl[45] br[45] wl[0] gnd reram_bitcell_7
Xbit_r1_c45 bl[45] br[45] wl[1] gnd reram_bitcell_7
Xbit_r2_c45 bl[45] br[45] wl[2] gnd reram_bitcell_7
Xbit_r3_c45 bl[45] br[45] wl[3] gnd reram_bitcell_7
Xbit_r4_c45 bl[45] br[45] wl[4] gnd reram_bitcell_7
Xbit_r5_c45 bl[45] br[45] wl[5] gnd reram_bitcell_7
Xbit_r6_c45 bl[45] br[45] wl[6] gnd reram_bitcell_7
Xbit_r7_c45 bl[45] br[45] wl[7] gnd reram_bitcell_7
Xbit_r8_c45 bl[45] br[45] wl[8] gnd reram_bitcell_7
Xbit_r9_c45 bl[45] br[45] wl[9] gnd reram_bitcell_7
Xbit_r10_c45 bl[45] br[45] wl[10] gnd reram_bitcell_7
Xbit_r11_c45 bl[45] br[45] wl[11] gnd reram_bitcell_7
Xbit_r12_c45 bl[45] br[45] wl[12] gnd reram_bitcell_7
Xbit_r13_c45 bl[45] br[45] wl[13] gnd reram_bitcell_7
Xbit_r14_c45 bl[45] br[45] wl[14] gnd reram_bitcell_7
Xbit_r15_c45 bl[45] br[45] wl[15] gnd reram_bitcell_7
Xbit_r16_c45 bl[45] br[45] wl[16] gnd reram_bitcell_7
Xbit_r17_c45 bl[45] br[45] wl[17] gnd reram_bitcell_7
Xbit_r18_c45 bl[45] br[45] wl[18] gnd reram_bitcell_7
Xbit_r19_c45 bl[45] br[45] wl[19] gnd reram_bitcell_7
Xbit_r20_c45 bl[45] br[45] wl[20] gnd reram_bitcell_7
Xbit_r21_c45 bl[45] br[45] wl[21] gnd reram_bitcell_7
Xbit_r22_c45 bl[45] br[45] wl[22] gnd reram_bitcell_7
Xbit_r23_c45 bl[45] br[45] wl[23] gnd reram_bitcell_7
Xbit_r24_c45 bl[45] br[45] wl[24] gnd reram_bitcell_7
Xbit_r25_c45 bl[45] br[45] wl[25] gnd reram_bitcell_7
Xbit_r26_c45 bl[45] br[45] wl[26] gnd reram_bitcell_7
Xbit_r27_c45 bl[45] br[45] wl[27] gnd reram_bitcell_7
Xbit_r28_c45 bl[45] br[45] wl[28] gnd reram_bitcell_7
Xbit_r29_c45 bl[45] br[45] wl[29] gnd reram_bitcell_7
Xbit_r30_c45 bl[45] br[45] wl[30] gnd reram_bitcell_7
Xbit_r31_c45 bl[45] br[45] wl[31] gnd reram_bitcell_7
Xbit_r0_c46 bl[46] br[46] wl[0] gnd reram_bitcell_7
Xbit_r1_c46 bl[46] br[46] wl[1] gnd reram_bitcell_7
Xbit_r2_c46 bl[46] br[46] wl[2] gnd reram_bitcell_7
Xbit_r3_c46 bl[46] br[46] wl[3] gnd reram_bitcell_7
Xbit_r4_c46 bl[46] br[46] wl[4] gnd reram_bitcell_7
Xbit_r5_c46 bl[46] br[46] wl[5] gnd reram_bitcell_7
Xbit_r6_c46 bl[46] br[46] wl[6] gnd reram_bitcell_7
Xbit_r7_c46 bl[46] br[46] wl[7] gnd reram_bitcell_7
Xbit_r8_c46 bl[46] br[46] wl[8] gnd reram_bitcell_7
Xbit_r9_c46 bl[46] br[46] wl[9] gnd reram_bitcell_7
Xbit_r10_c46 bl[46] br[46] wl[10] gnd reram_bitcell_7
Xbit_r11_c46 bl[46] br[46] wl[11] gnd reram_bitcell_7
Xbit_r12_c46 bl[46] br[46] wl[12] gnd reram_bitcell_7
Xbit_r13_c46 bl[46] br[46] wl[13] gnd reram_bitcell_7
Xbit_r14_c46 bl[46] br[46] wl[14] gnd reram_bitcell_7
Xbit_r15_c46 bl[46] br[46] wl[15] gnd reram_bitcell_7
Xbit_r16_c46 bl[46] br[46] wl[16] gnd reram_bitcell_7
Xbit_r17_c46 bl[46] br[46] wl[17] gnd reram_bitcell_7
Xbit_r18_c46 bl[46] br[46] wl[18] gnd reram_bitcell_7
Xbit_r19_c46 bl[46] br[46] wl[19] gnd reram_bitcell_7
Xbit_r20_c46 bl[46] br[46] wl[20] gnd reram_bitcell_7
Xbit_r21_c46 bl[46] br[46] wl[21] gnd reram_bitcell_7
Xbit_r22_c46 bl[46] br[46] wl[22] gnd reram_bitcell_7
Xbit_r23_c46 bl[46] br[46] wl[23] gnd reram_bitcell_7
Xbit_r24_c46 bl[46] br[46] wl[24] gnd reram_bitcell_7
Xbit_r25_c46 bl[46] br[46] wl[25] gnd reram_bitcell_7
Xbit_r26_c46 bl[46] br[46] wl[26] gnd reram_bitcell_7
Xbit_r27_c46 bl[46] br[46] wl[27] gnd reram_bitcell_7
Xbit_r28_c46 bl[46] br[46] wl[28] gnd reram_bitcell_7
Xbit_r29_c46 bl[46] br[46] wl[29] gnd reram_bitcell_7
Xbit_r30_c46 bl[46] br[46] wl[30] gnd reram_bitcell_7
Xbit_r31_c46 bl[46] br[46] wl[31] gnd reram_bitcell_7
Xbit_r0_c47 bl[47] br[47] wl[0] gnd reram_bitcell_7
Xbit_r1_c47 bl[47] br[47] wl[1] gnd reram_bitcell_7
Xbit_r2_c47 bl[47] br[47] wl[2] gnd reram_bitcell_7
Xbit_r3_c47 bl[47] br[47] wl[3] gnd reram_bitcell_7
Xbit_r4_c47 bl[47] br[47] wl[4] gnd reram_bitcell_7
Xbit_r5_c47 bl[47] br[47] wl[5] gnd reram_bitcell_7
Xbit_r6_c47 bl[47] br[47] wl[6] gnd reram_bitcell_7
Xbit_r7_c47 bl[47] br[47] wl[7] gnd reram_bitcell_7
Xbit_r8_c47 bl[47] br[47] wl[8] gnd reram_bitcell_7
Xbit_r9_c47 bl[47] br[47] wl[9] gnd reram_bitcell_7
Xbit_r10_c47 bl[47] br[47] wl[10] gnd reram_bitcell_7
Xbit_r11_c47 bl[47] br[47] wl[11] gnd reram_bitcell_7
Xbit_r12_c47 bl[47] br[47] wl[12] gnd reram_bitcell_7
Xbit_r13_c47 bl[47] br[47] wl[13] gnd reram_bitcell_7
Xbit_r14_c47 bl[47] br[47] wl[14] gnd reram_bitcell_7
Xbit_r15_c47 bl[47] br[47] wl[15] gnd reram_bitcell_7
Xbit_r16_c47 bl[47] br[47] wl[16] gnd reram_bitcell_7
Xbit_r17_c47 bl[47] br[47] wl[17] gnd reram_bitcell_7
Xbit_r18_c47 bl[47] br[47] wl[18] gnd reram_bitcell_7
Xbit_r19_c47 bl[47] br[47] wl[19] gnd reram_bitcell_7
Xbit_r20_c47 bl[47] br[47] wl[20] gnd reram_bitcell_7
Xbit_r21_c47 bl[47] br[47] wl[21] gnd reram_bitcell_7
Xbit_r22_c47 bl[47] br[47] wl[22] gnd reram_bitcell_7
Xbit_r23_c47 bl[47] br[47] wl[23] gnd reram_bitcell_7
Xbit_r24_c47 bl[47] br[47] wl[24] gnd reram_bitcell_7
Xbit_r25_c47 bl[47] br[47] wl[25] gnd reram_bitcell_7
Xbit_r26_c47 bl[47] br[47] wl[26] gnd reram_bitcell_7
Xbit_r27_c47 bl[47] br[47] wl[27] gnd reram_bitcell_7
Xbit_r28_c47 bl[47] br[47] wl[28] gnd reram_bitcell_7
Xbit_r29_c47 bl[47] br[47] wl[29] gnd reram_bitcell_7
Xbit_r30_c47 bl[47] br[47] wl[30] gnd reram_bitcell_7
Xbit_r31_c47 bl[47] br[47] wl[31] gnd reram_bitcell_7
Xbit_r0_c48 bl[48] br[48] wl[0] gnd reram_bitcell_7
Xbit_r1_c48 bl[48] br[48] wl[1] gnd reram_bitcell_7
Xbit_r2_c48 bl[48] br[48] wl[2] gnd reram_bitcell_7
Xbit_r3_c48 bl[48] br[48] wl[3] gnd reram_bitcell_7
Xbit_r4_c48 bl[48] br[48] wl[4] gnd reram_bitcell_7
Xbit_r5_c48 bl[48] br[48] wl[5] gnd reram_bitcell_7
Xbit_r6_c48 bl[48] br[48] wl[6] gnd reram_bitcell_7
Xbit_r7_c48 bl[48] br[48] wl[7] gnd reram_bitcell_7
Xbit_r8_c48 bl[48] br[48] wl[8] gnd reram_bitcell_7
Xbit_r9_c48 bl[48] br[48] wl[9] gnd reram_bitcell_7
Xbit_r10_c48 bl[48] br[48] wl[10] gnd reram_bitcell_7
Xbit_r11_c48 bl[48] br[48] wl[11] gnd reram_bitcell_7
Xbit_r12_c48 bl[48] br[48] wl[12] gnd reram_bitcell_7
Xbit_r13_c48 bl[48] br[48] wl[13] gnd reram_bitcell_7
Xbit_r14_c48 bl[48] br[48] wl[14] gnd reram_bitcell_7
Xbit_r15_c48 bl[48] br[48] wl[15] gnd reram_bitcell_7
Xbit_r16_c48 bl[48] br[48] wl[16] gnd reram_bitcell_7
Xbit_r17_c48 bl[48] br[48] wl[17] gnd reram_bitcell_7
Xbit_r18_c48 bl[48] br[48] wl[18] gnd reram_bitcell_7
Xbit_r19_c48 bl[48] br[48] wl[19] gnd reram_bitcell_7
Xbit_r20_c48 bl[48] br[48] wl[20] gnd reram_bitcell_7
Xbit_r21_c48 bl[48] br[48] wl[21] gnd reram_bitcell_7
Xbit_r22_c48 bl[48] br[48] wl[22] gnd reram_bitcell_7
Xbit_r23_c48 bl[48] br[48] wl[23] gnd reram_bitcell_7
Xbit_r24_c48 bl[48] br[48] wl[24] gnd reram_bitcell_7
Xbit_r25_c48 bl[48] br[48] wl[25] gnd reram_bitcell_7
Xbit_r26_c48 bl[48] br[48] wl[26] gnd reram_bitcell_7
Xbit_r27_c48 bl[48] br[48] wl[27] gnd reram_bitcell_7
Xbit_r28_c48 bl[48] br[48] wl[28] gnd reram_bitcell_7
Xbit_r29_c48 bl[48] br[48] wl[29] gnd reram_bitcell_7
Xbit_r30_c48 bl[48] br[48] wl[30] gnd reram_bitcell_7
Xbit_r31_c48 bl[48] br[48] wl[31] gnd reram_bitcell_7
Xbit_r0_c49 bl[49] br[49] wl[0] gnd reram_bitcell_7
Xbit_r1_c49 bl[49] br[49] wl[1] gnd reram_bitcell_7
Xbit_r2_c49 bl[49] br[49] wl[2] gnd reram_bitcell_7
Xbit_r3_c49 bl[49] br[49] wl[3] gnd reram_bitcell_7
Xbit_r4_c49 bl[49] br[49] wl[4] gnd reram_bitcell_7
Xbit_r5_c49 bl[49] br[49] wl[5] gnd reram_bitcell_7
Xbit_r6_c49 bl[49] br[49] wl[6] gnd reram_bitcell_7
Xbit_r7_c49 bl[49] br[49] wl[7] gnd reram_bitcell_7
Xbit_r8_c49 bl[49] br[49] wl[8] gnd reram_bitcell_7
Xbit_r9_c49 bl[49] br[49] wl[9] gnd reram_bitcell_7
Xbit_r10_c49 bl[49] br[49] wl[10] gnd reram_bitcell_7
Xbit_r11_c49 bl[49] br[49] wl[11] gnd reram_bitcell_7
Xbit_r12_c49 bl[49] br[49] wl[12] gnd reram_bitcell_7
Xbit_r13_c49 bl[49] br[49] wl[13] gnd reram_bitcell_7
Xbit_r14_c49 bl[49] br[49] wl[14] gnd reram_bitcell_7
Xbit_r15_c49 bl[49] br[49] wl[15] gnd reram_bitcell_7
Xbit_r16_c49 bl[49] br[49] wl[16] gnd reram_bitcell_7
Xbit_r17_c49 bl[49] br[49] wl[17] gnd reram_bitcell_7
Xbit_r18_c49 bl[49] br[49] wl[18] gnd reram_bitcell_7
Xbit_r19_c49 bl[49] br[49] wl[19] gnd reram_bitcell_7
Xbit_r20_c49 bl[49] br[49] wl[20] gnd reram_bitcell_7
Xbit_r21_c49 bl[49] br[49] wl[21] gnd reram_bitcell_7
Xbit_r22_c49 bl[49] br[49] wl[22] gnd reram_bitcell_7
Xbit_r23_c49 bl[49] br[49] wl[23] gnd reram_bitcell_7
Xbit_r24_c49 bl[49] br[49] wl[24] gnd reram_bitcell_7
Xbit_r25_c49 bl[49] br[49] wl[25] gnd reram_bitcell_7
Xbit_r26_c49 bl[49] br[49] wl[26] gnd reram_bitcell_7
Xbit_r27_c49 bl[49] br[49] wl[27] gnd reram_bitcell_7
Xbit_r28_c49 bl[49] br[49] wl[28] gnd reram_bitcell_7
Xbit_r29_c49 bl[49] br[49] wl[29] gnd reram_bitcell_7
Xbit_r30_c49 bl[49] br[49] wl[30] gnd reram_bitcell_7
Xbit_r31_c49 bl[49] br[49] wl[31] gnd reram_bitcell_7
Xbit_r0_c50 bl[50] br[50] wl[0] gnd reram_bitcell_7
Xbit_r1_c50 bl[50] br[50] wl[1] gnd reram_bitcell_7
Xbit_r2_c50 bl[50] br[50] wl[2] gnd reram_bitcell_7
Xbit_r3_c50 bl[50] br[50] wl[3] gnd reram_bitcell_7
Xbit_r4_c50 bl[50] br[50] wl[4] gnd reram_bitcell_7
Xbit_r5_c50 bl[50] br[50] wl[5] gnd reram_bitcell_7
Xbit_r6_c50 bl[50] br[50] wl[6] gnd reram_bitcell_7
Xbit_r7_c50 bl[50] br[50] wl[7] gnd reram_bitcell_7
Xbit_r8_c50 bl[50] br[50] wl[8] gnd reram_bitcell_7
Xbit_r9_c50 bl[50] br[50] wl[9] gnd reram_bitcell_7
Xbit_r10_c50 bl[50] br[50] wl[10] gnd reram_bitcell_7
Xbit_r11_c50 bl[50] br[50] wl[11] gnd reram_bitcell_7
Xbit_r12_c50 bl[50] br[50] wl[12] gnd reram_bitcell_7
Xbit_r13_c50 bl[50] br[50] wl[13] gnd reram_bitcell_7
Xbit_r14_c50 bl[50] br[50] wl[14] gnd reram_bitcell_7
Xbit_r15_c50 bl[50] br[50] wl[15] gnd reram_bitcell_7
Xbit_r16_c50 bl[50] br[50] wl[16] gnd reram_bitcell_7
Xbit_r17_c50 bl[50] br[50] wl[17] gnd reram_bitcell_7
Xbit_r18_c50 bl[50] br[50] wl[18] gnd reram_bitcell_7
Xbit_r19_c50 bl[50] br[50] wl[19] gnd reram_bitcell_7
Xbit_r20_c50 bl[50] br[50] wl[20] gnd reram_bitcell_7
Xbit_r21_c50 bl[50] br[50] wl[21] gnd reram_bitcell_7
Xbit_r22_c50 bl[50] br[50] wl[22] gnd reram_bitcell_7
Xbit_r23_c50 bl[50] br[50] wl[23] gnd reram_bitcell_7
Xbit_r24_c50 bl[50] br[50] wl[24] gnd reram_bitcell_7
Xbit_r25_c50 bl[50] br[50] wl[25] gnd reram_bitcell_7
Xbit_r26_c50 bl[50] br[50] wl[26] gnd reram_bitcell_7
Xbit_r27_c50 bl[50] br[50] wl[27] gnd reram_bitcell_7
Xbit_r28_c50 bl[50] br[50] wl[28] gnd reram_bitcell_7
Xbit_r29_c50 bl[50] br[50] wl[29] gnd reram_bitcell_7
Xbit_r30_c50 bl[50] br[50] wl[30] gnd reram_bitcell_7
Xbit_r31_c50 bl[50] br[50] wl[31] gnd reram_bitcell_7
Xbit_r0_c51 bl[51] br[51] wl[0] gnd reram_bitcell_7
Xbit_r1_c51 bl[51] br[51] wl[1] gnd reram_bitcell_7
Xbit_r2_c51 bl[51] br[51] wl[2] gnd reram_bitcell_7
Xbit_r3_c51 bl[51] br[51] wl[3] gnd reram_bitcell_7
Xbit_r4_c51 bl[51] br[51] wl[4] gnd reram_bitcell_7
Xbit_r5_c51 bl[51] br[51] wl[5] gnd reram_bitcell_7
Xbit_r6_c51 bl[51] br[51] wl[6] gnd reram_bitcell_7
Xbit_r7_c51 bl[51] br[51] wl[7] gnd reram_bitcell_7
Xbit_r8_c51 bl[51] br[51] wl[8] gnd reram_bitcell_7
Xbit_r9_c51 bl[51] br[51] wl[9] gnd reram_bitcell_7
Xbit_r10_c51 bl[51] br[51] wl[10] gnd reram_bitcell_7
Xbit_r11_c51 bl[51] br[51] wl[11] gnd reram_bitcell_7
Xbit_r12_c51 bl[51] br[51] wl[12] gnd reram_bitcell_7
Xbit_r13_c51 bl[51] br[51] wl[13] gnd reram_bitcell_7
Xbit_r14_c51 bl[51] br[51] wl[14] gnd reram_bitcell_7
Xbit_r15_c51 bl[51] br[51] wl[15] gnd reram_bitcell_7
Xbit_r16_c51 bl[51] br[51] wl[16] gnd reram_bitcell_7
Xbit_r17_c51 bl[51] br[51] wl[17] gnd reram_bitcell_7
Xbit_r18_c51 bl[51] br[51] wl[18] gnd reram_bitcell_7
Xbit_r19_c51 bl[51] br[51] wl[19] gnd reram_bitcell_7
Xbit_r20_c51 bl[51] br[51] wl[20] gnd reram_bitcell_7
Xbit_r21_c51 bl[51] br[51] wl[21] gnd reram_bitcell_7
Xbit_r22_c51 bl[51] br[51] wl[22] gnd reram_bitcell_7
Xbit_r23_c51 bl[51] br[51] wl[23] gnd reram_bitcell_7
Xbit_r24_c51 bl[51] br[51] wl[24] gnd reram_bitcell_7
Xbit_r25_c51 bl[51] br[51] wl[25] gnd reram_bitcell_7
Xbit_r26_c51 bl[51] br[51] wl[26] gnd reram_bitcell_7
Xbit_r27_c51 bl[51] br[51] wl[27] gnd reram_bitcell_7
Xbit_r28_c51 bl[51] br[51] wl[28] gnd reram_bitcell_7
Xbit_r29_c51 bl[51] br[51] wl[29] gnd reram_bitcell_7
Xbit_r30_c51 bl[51] br[51] wl[30] gnd reram_bitcell_7
Xbit_r31_c51 bl[51] br[51] wl[31] gnd reram_bitcell_7
Xbit_r0_c52 bl[52] br[52] wl[0] gnd reram_bitcell_7
Xbit_r1_c52 bl[52] br[52] wl[1] gnd reram_bitcell_7
Xbit_r2_c52 bl[52] br[52] wl[2] gnd reram_bitcell_7
Xbit_r3_c52 bl[52] br[52] wl[3] gnd reram_bitcell_7
Xbit_r4_c52 bl[52] br[52] wl[4] gnd reram_bitcell_7
Xbit_r5_c52 bl[52] br[52] wl[5] gnd reram_bitcell_7
Xbit_r6_c52 bl[52] br[52] wl[6] gnd reram_bitcell_7
Xbit_r7_c52 bl[52] br[52] wl[7] gnd reram_bitcell_7
Xbit_r8_c52 bl[52] br[52] wl[8] gnd reram_bitcell_7
Xbit_r9_c52 bl[52] br[52] wl[9] gnd reram_bitcell_7
Xbit_r10_c52 bl[52] br[52] wl[10] gnd reram_bitcell_7
Xbit_r11_c52 bl[52] br[52] wl[11] gnd reram_bitcell_7
Xbit_r12_c52 bl[52] br[52] wl[12] gnd reram_bitcell_7
Xbit_r13_c52 bl[52] br[52] wl[13] gnd reram_bitcell_7
Xbit_r14_c52 bl[52] br[52] wl[14] gnd reram_bitcell_7
Xbit_r15_c52 bl[52] br[52] wl[15] gnd reram_bitcell_7
Xbit_r16_c52 bl[52] br[52] wl[16] gnd reram_bitcell_7
Xbit_r17_c52 bl[52] br[52] wl[17] gnd reram_bitcell_7
Xbit_r18_c52 bl[52] br[52] wl[18] gnd reram_bitcell_7
Xbit_r19_c52 bl[52] br[52] wl[19] gnd reram_bitcell_7
Xbit_r20_c52 bl[52] br[52] wl[20] gnd reram_bitcell_7
Xbit_r21_c52 bl[52] br[52] wl[21] gnd reram_bitcell_7
Xbit_r22_c52 bl[52] br[52] wl[22] gnd reram_bitcell_7
Xbit_r23_c52 bl[52] br[52] wl[23] gnd reram_bitcell_7
Xbit_r24_c52 bl[52] br[52] wl[24] gnd reram_bitcell_7
Xbit_r25_c52 bl[52] br[52] wl[25] gnd reram_bitcell_7
Xbit_r26_c52 bl[52] br[52] wl[26] gnd reram_bitcell_7
Xbit_r27_c52 bl[52] br[52] wl[27] gnd reram_bitcell_7
Xbit_r28_c52 bl[52] br[52] wl[28] gnd reram_bitcell_7
Xbit_r29_c52 bl[52] br[52] wl[29] gnd reram_bitcell_7
Xbit_r30_c52 bl[52] br[52] wl[30] gnd reram_bitcell_7
Xbit_r31_c52 bl[52] br[52] wl[31] gnd reram_bitcell_7
Xbit_r0_c53 bl[53] br[53] wl[0] gnd reram_bitcell_7
Xbit_r1_c53 bl[53] br[53] wl[1] gnd reram_bitcell_7
Xbit_r2_c53 bl[53] br[53] wl[2] gnd reram_bitcell_7
Xbit_r3_c53 bl[53] br[53] wl[3] gnd reram_bitcell_7
Xbit_r4_c53 bl[53] br[53] wl[4] gnd reram_bitcell_7
Xbit_r5_c53 bl[53] br[53] wl[5] gnd reram_bitcell_7
Xbit_r6_c53 bl[53] br[53] wl[6] gnd reram_bitcell_7
Xbit_r7_c53 bl[53] br[53] wl[7] gnd reram_bitcell_7
Xbit_r8_c53 bl[53] br[53] wl[8] gnd reram_bitcell_7
Xbit_r9_c53 bl[53] br[53] wl[9] gnd reram_bitcell_7
Xbit_r10_c53 bl[53] br[53] wl[10] gnd reram_bitcell_7
Xbit_r11_c53 bl[53] br[53] wl[11] gnd reram_bitcell_7
Xbit_r12_c53 bl[53] br[53] wl[12] gnd reram_bitcell_7
Xbit_r13_c53 bl[53] br[53] wl[13] gnd reram_bitcell_7
Xbit_r14_c53 bl[53] br[53] wl[14] gnd reram_bitcell_7
Xbit_r15_c53 bl[53] br[53] wl[15] gnd reram_bitcell_7
Xbit_r16_c53 bl[53] br[53] wl[16] gnd reram_bitcell_7
Xbit_r17_c53 bl[53] br[53] wl[17] gnd reram_bitcell_7
Xbit_r18_c53 bl[53] br[53] wl[18] gnd reram_bitcell_7
Xbit_r19_c53 bl[53] br[53] wl[19] gnd reram_bitcell_7
Xbit_r20_c53 bl[53] br[53] wl[20] gnd reram_bitcell_7
Xbit_r21_c53 bl[53] br[53] wl[21] gnd reram_bitcell_7
Xbit_r22_c53 bl[53] br[53] wl[22] gnd reram_bitcell_7
Xbit_r23_c53 bl[53] br[53] wl[23] gnd reram_bitcell_7
Xbit_r24_c53 bl[53] br[53] wl[24] gnd reram_bitcell_7
Xbit_r25_c53 bl[53] br[53] wl[25] gnd reram_bitcell_7
Xbit_r26_c53 bl[53] br[53] wl[26] gnd reram_bitcell_7
Xbit_r27_c53 bl[53] br[53] wl[27] gnd reram_bitcell_7
Xbit_r28_c53 bl[53] br[53] wl[28] gnd reram_bitcell_7
Xbit_r29_c53 bl[53] br[53] wl[29] gnd reram_bitcell_7
Xbit_r30_c53 bl[53] br[53] wl[30] gnd reram_bitcell_7
Xbit_r31_c53 bl[53] br[53] wl[31] gnd reram_bitcell_7
Xbit_r0_c54 bl[54] br[54] wl[0] gnd reram_bitcell_7
Xbit_r1_c54 bl[54] br[54] wl[1] gnd reram_bitcell_7
Xbit_r2_c54 bl[54] br[54] wl[2] gnd reram_bitcell_7
Xbit_r3_c54 bl[54] br[54] wl[3] gnd reram_bitcell_7
Xbit_r4_c54 bl[54] br[54] wl[4] gnd reram_bitcell_7
Xbit_r5_c54 bl[54] br[54] wl[5] gnd reram_bitcell_7
Xbit_r6_c54 bl[54] br[54] wl[6] gnd reram_bitcell_7
Xbit_r7_c54 bl[54] br[54] wl[7] gnd reram_bitcell_7
Xbit_r8_c54 bl[54] br[54] wl[8] gnd reram_bitcell_7
Xbit_r9_c54 bl[54] br[54] wl[9] gnd reram_bitcell_7
Xbit_r10_c54 bl[54] br[54] wl[10] gnd reram_bitcell_7
Xbit_r11_c54 bl[54] br[54] wl[11] gnd reram_bitcell_7
Xbit_r12_c54 bl[54] br[54] wl[12] gnd reram_bitcell_7
Xbit_r13_c54 bl[54] br[54] wl[13] gnd reram_bitcell_7
Xbit_r14_c54 bl[54] br[54] wl[14] gnd reram_bitcell_7
Xbit_r15_c54 bl[54] br[54] wl[15] gnd reram_bitcell_7
Xbit_r16_c54 bl[54] br[54] wl[16] gnd reram_bitcell_7
Xbit_r17_c54 bl[54] br[54] wl[17] gnd reram_bitcell_7
Xbit_r18_c54 bl[54] br[54] wl[18] gnd reram_bitcell_7
Xbit_r19_c54 bl[54] br[54] wl[19] gnd reram_bitcell_7
Xbit_r20_c54 bl[54] br[54] wl[20] gnd reram_bitcell_7
Xbit_r21_c54 bl[54] br[54] wl[21] gnd reram_bitcell_7
Xbit_r22_c54 bl[54] br[54] wl[22] gnd reram_bitcell_7
Xbit_r23_c54 bl[54] br[54] wl[23] gnd reram_bitcell_7
Xbit_r24_c54 bl[54] br[54] wl[24] gnd reram_bitcell_7
Xbit_r25_c54 bl[54] br[54] wl[25] gnd reram_bitcell_7
Xbit_r26_c54 bl[54] br[54] wl[26] gnd reram_bitcell_7
Xbit_r27_c54 bl[54] br[54] wl[27] gnd reram_bitcell_7
Xbit_r28_c54 bl[54] br[54] wl[28] gnd reram_bitcell_7
Xbit_r29_c54 bl[54] br[54] wl[29] gnd reram_bitcell_7
Xbit_r30_c54 bl[54] br[54] wl[30] gnd reram_bitcell_7
Xbit_r31_c54 bl[54] br[54] wl[31] gnd reram_bitcell_7
Xbit_r0_c55 bl[55] br[55] wl[0] gnd reram_bitcell_7
Xbit_r1_c55 bl[55] br[55] wl[1] gnd reram_bitcell_7
Xbit_r2_c55 bl[55] br[55] wl[2] gnd reram_bitcell_7
Xbit_r3_c55 bl[55] br[55] wl[3] gnd reram_bitcell_7
Xbit_r4_c55 bl[55] br[55] wl[4] gnd reram_bitcell_7
Xbit_r5_c55 bl[55] br[55] wl[5] gnd reram_bitcell_7
Xbit_r6_c55 bl[55] br[55] wl[6] gnd reram_bitcell_7
Xbit_r7_c55 bl[55] br[55] wl[7] gnd reram_bitcell_7
Xbit_r8_c55 bl[55] br[55] wl[8] gnd reram_bitcell_7
Xbit_r9_c55 bl[55] br[55] wl[9] gnd reram_bitcell_7
Xbit_r10_c55 bl[55] br[55] wl[10] gnd reram_bitcell_7
Xbit_r11_c55 bl[55] br[55] wl[11] gnd reram_bitcell_7
Xbit_r12_c55 bl[55] br[55] wl[12] gnd reram_bitcell_7
Xbit_r13_c55 bl[55] br[55] wl[13] gnd reram_bitcell_7
Xbit_r14_c55 bl[55] br[55] wl[14] gnd reram_bitcell_7
Xbit_r15_c55 bl[55] br[55] wl[15] gnd reram_bitcell_7
Xbit_r16_c55 bl[55] br[55] wl[16] gnd reram_bitcell_7
Xbit_r17_c55 bl[55] br[55] wl[17] gnd reram_bitcell_7
Xbit_r18_c55 bl[55] br[55] wl[18] gnd reram_bitcell_7
Xbit_r19_c55 bl[55] br[55] wl[19] gnd reram_bitcell_7
Xbit_r20_c55 bl[55] br[55] wl[20] gnd reram_bitcell_7
Xbit_r21_c55 bl[55] br[55] wl[21] gnd reram_bitcell_7
Xbit_r22_c55 bl[55] br[55] wl[22] gnd reram_bitcell_7
Xbit_r23_c55 bl[55] br[55] wl[23] gnd reram_bitcell_7
Xbit_r24_c55 bl[55] br[55] wl[24] gnd reram_bitcell_7
Xbit_r25_c55 bl[55] br[55] wl[25] gnd reram_bitcell_7
Xbit_r26_c55 bl[55] br[55] wl[26] gnd reram_bitcell_7
Xbit_r27_c55 bl[55] br[55] wl[27] gnd reram_bitcell_7
Xbit_r28_c55 bl[55] br[55] wl[28] gnd reram_bitcell_7
Xbit_r29_c55 bl[55] br[55] wl[29] gnd reram_bitcell_7
Xbit_r30_c55 bl[55] br[55] wl[30] gnd reram_bitcell_7
Xbit_r31_c55 bl[55] br[55] wl[31] gnd reram_bitcell_7
Xbit_r0_c56 bl[56] br[56] wl[0] gnd reram_bitcell_7
Xbit_r1_c56 bl[56] br[56] wl[1] gnd reram_bitcell_7
Xbit_r2_c56 bl[56] br[56] wl[2] gnd reram_bitcell_7
Xbit_r3_c56 bl[56] br[56] wl[3] gnd reram_bitcell_7
Xbit_r4_c56 bl[56] br[56] wl[4] gnd reram_bitcell_7
Xbit_r5_c56 bl[56] br[56] wl[5] gnd reram_bitcell_7
Xbit_r6_c56 bl[56] br[56] wl[6] gnd reram_bitcell_7
Xbit_r7_c56 bl[56] br[56] wl[7] gnd reram_bitcell_7
Xbit_r8_c56 bl[56] br[56] wl[8] gnd reram_bitcell_7
Xbit_r9_c56 bl[56] br[56] wl[9] gnd reram_bitcell_7
Xbit_r10_c56 bl[56] br[56] wl[10] gnd reram_bitcell_7
Xbit_r11_c56 bl[56] br[56] wl[11] gnd reram_bitcell_7
Xbit_r12_c56 bl[56] br[56] wl[12] gnd reram_bitcell_7
Xbit_r13_c56 bl[56] br[56] wl[13] gnd reram_bitcell_7
Xbit_r14_c56 bl[56] br[56] wl[14] gnd reram_bitcell_7
Xbit_r15_c56 bl[56] br[56] wl[15] gnd reram_bitcell_7
Xbit_r16_c56 bl[56] br[56] wl[16] gnd reram_bitcell_7
Xbit_r17_c56 bl[56] br[56] wl[17] gnd reram_bitcell_7
Xbit_r18_c56 bl[56] br[56] wl[18] gnd reram_bitcell_7
Xbit_r19_c56 bl[56] br[56] wl[19] gnd reram_bitcell_7
Xbit_r20_c56 bl[56] br[56] wl[20] gnd reram_bitcell_7
Xbit_r21_c56 bl[56] br[56] wl[21] gnd reram_bitcell_7
Xbit_r22_c56 bl[56] br[56] wl[22] gnd reram_bitcell_7
Xbit_r23_c56 bl[56] br[56] wl[23] gnd reram_bitcell_7
Xbit_r24_c56 bl[56] br[56] wl[24] gnd reram_bitcell_7
Xbit_r25_c56 bl[56] br[56] wl[25] gnd reram_bitcell_7
Xbit_r26_c56 bl[56] br[56] wl[26] gnd reram_bitcell_7
Xbit_r27_c56 bl[56] br[56] wl[27] gnd reram_bitcell_7
Xbit_r28_c56 bl[56] br[56] wl[28] gnd reram_bitcell_7
Xbit_r29_c56 bl[56] br[56] wl[29] gnd reram_bitcell_7
Xbit_r30_c56 bl[56] br[56] wl[30] gnd reram_bitcell_7
Xbit_r31_c56 bl[56] br[56] wl[31] gnd reram_bitcell_7
Xbit_r0_c57 bl[57] br[57] wl[0] gnd reram_bitcell_7
Xbit_r1_c57 bl[57] br[57] wl[1] gnd reram_bitcell_7
Xbit_r2_c57 bl[57] br[57] wl[2] gnd reram_bitcell_7
Xbit_r3_c57 bl[57] br[57] wl[3] gnd reram_bitcell_7
Xbit_r4_c57 bl[57] br[57] wl[4] gnd reram_bitcell_7
Xbit_r5_c57 bl[57] br[57] wl[5] gnd reram_bitcell_7
Xbit_r6_c57 bl[57] br[57] wl[6] gnd reram_bitcell_7
Xbit_r7_c57 bl[57] br[57] wl[7] gnd reram_bitcell_7
Xbit_r8_c57 bl[57] br[57] wl[8] gnd reram_bitcell_7
Xbit_r9_c57 bl[57] br[57] wl[9] gnd reram_bitcell_7
Xbit_r10_c57 bl[57] br[57] wl[10] gnd reram_bitcell_7
Xbit_r11_c57 bl[57] br[57] wl[11] gnd reram_bitcell_7
Xbit_r12_c57 bl[57] br[57] wl[12] gnd reram_bitcell_7
Xbit_r13_c57 bl[57] br[57] wl[13] gnd reram_bitcell_7
Xbit_r14_c57 bl[57] br[57] wl[14] gnd reram_bitcell_7
Xbit_r15_c57 bl[57] br[57] wl[15] gnd reram_bitcell_7
Xbit_r16_c57 bl[57] br[57] wl[16] gnd reram_bitcell_7
Xbit_r17_c57 bl[57] br[57] wl[17] gnd reram_bitcell_7
Xbit_r18_c57 bl[57] br[57] wl[18] gnd reram_bitcell_7
Xbit_r19_c57 bl[57] br[57] wl[19] gnd reram_bitcell_7
Xbit_r20_c57 bl[57] br[57] wl[20] gnd reram_bitcell_7
Xbit_r21_c57 bl[57] br[57] wl[21] gnd reram_bitcell_7
Xbit_r22_c57 bl[57] br[57] wl[22] gnd reram_bitcell_7
Xbit_r23_c57 bl[57] br[57] wl[23] gnd reram_bitcell_7
Xbit_r24_c57 bl[57] br[57] wl[24] gnd reram_bitcell_7
Xbit_r25_c57 bl[57] br[57] wl[25] gnd reram_bitcell_7
Xbit_r26_c57 bl[57] br[57] wl[26] gnd reram_bitcell_7
Xbit_r27_c57 bl[57] br[57] wl[27] gnd reram_bitcell_7
Xbit_r28_c57 bl[57] br[57] wl[28] gnd reram_bitcell_7
Xbit_r29_c57 bl[57] br[57] wl[29] gnd reram_bitcell_7
Xbit_r30_c57 bl[57] br[57] wl[30] gnd reram_bitcell_7
Xbit_r31_c57 bl[57] br[57] wl[31] gnd reram_bitcell_7
Xbit_r0_c58 bl[58] br[58] wl[0] gnd reram_bitcell_7
Xbit_r1_c58 bl[58] br[58] wl[1] gnd reram_bitcell_7
Xbit_r2_c58 bl[58] br[58] wl[2] gnd reram_bitcell_7
Xbit_r3_c58 bl[58] br[58] wl[3] gnd reram_bitcell_7
Xbit_r4_c58 bl[58] br[58] wl[4] gnd reram_bitcell_7
Xbit_r5_c58 bl[58] br[58] wl[5] gnd reram_bitcell_7
Xbit_r6_c58 bl[58] br[58] wl[6] gnd reram_bitcell_7
Xbit_r7_c58 bl[58] br[58] wl[7] gnd reram_bitcell_7
Xbit_r8_c58 bl[58] br[58] wl[8] gnd reram_bitcell_7
Xbit_r9_c58 bl[58] br[58] wl[9] gnd reram_bitcell_7
Xbit_r10_c58 bl[58] br[58] wl[10] gnd reram_bitcell_7
Xbit_r11_c58 bl[58] br[58] wl[11] gnd reram_bitcell_7
Xbit_r12_c58 bl[58] br[58] wl[12] gnd reram_bitcell_7
Xbit_r13_c58 bl[58] br[58] wl[13] gnd reram_bitcell_7
Xbit_r14_c58 bl[58] br[58] wl[14] gnd reram_bitcell_7
Xbit_r15_c58 bl[58] br[58] wl[15] gnd reram_bitcell_7
Xbit_r16_c58 bl[58] br[58] wl[16] gnd reram_bitcell_7
Xbit_r17_c58 bl[58] br[58] wl[17] gnd reram_bitcell_7
Xbit_r18_c58 bl[58] br[58] wl[18] gnd reram_bitcell_7
Xbit_r19_c58 bl[58] br[58] wl[19] gnd reram_bitcell_7
Xbit_r20_c58 bl[58] br[58] wl[20] gnd reram_bitcell_7
Xbit_r21_c58 bl[58] br[58] wl[21] gnd reram_bitcell_7
Xbit_r22_c58 bl[58] br[58] wl[22] gnd reram_bitcell_7
Xbit_r23_c58 bl[58] br[58] wl[23] gnd reram_bitcell_7
Xbit_r24_c58 bl[58] br[58] wl[24] gnd reram_bitcell_7
Xbit_r25_c58 bl[58] br[58] wl[25] gnd reram_bitcell_7
Xbit_r26_c58 bl[58] br[58] wl[26] gnd reram_bitcell_7
Xbit_r27_c58 bl[58] br[58] wl[27] gnd reram_bitcell_7
Xbit_r28_c58 bl[58] br[58] wl[28] gnd reram_bitcell_7
Xbit_r29_c58 bl[58] br[58] wl[29] gnd reram_bitcell_7
Xbit_r30_c58 bl[58] br[58] wl[30] gnd reram_bitcell_7
Xbit_r31_c58 bl[58] br[58] wl[31] gnd reram_bitcell_7
Xbit_r0_c59 bl[59] br[59] wl[0] gnd reram_bitcell_7
Xbit_r1_c59 bl[59] br[59] wl[1] gnd reram_bitcell_7
Xbit_r2_c59 bl[59] br[59] wl[2] gnd reram_bitcell_7
Xbit_r3_c59 bl[59] br[59] wl[3] gnd reram_bitcell_7
Xbit_r4_c59 bl[59] br[59] wl[4] gnd reram_bitcell_7
Xbit_r5_c59 bl[59] br[59] wl[5] gnd reram_bitcell_7
Xbit_r6_c59 bl[59] br[59] wl[6] gnd reram_bitcell_7
Xbit_r7_c59 bl[59] br[59] wl[7] gnd reram_bitcell_7
Xbit_r8_c59 bl[59] br[59] wl[8] gnd reram_bitcell_7
Xbit_r9_c59 bl[59] br[59] wl[9] gnd reram_bitcell_7
Xbit_r10_c59 bl[59] br[59] wl[10] gnd reram_bitcell_7
Xbit_r11_c59 bl[59] br[59] wl[11] gnd reram_bitcell_7
Xbit_r12_c59 bl[59] br[59] wl[12] gnd reram_bitcell_7
Xbit_r13_c59 bl[59] br[59] wl[13] gnd reram_bitcell_7
Xbit_r14_c59 bl[59] br[59] wl[14] gnd reram_bitcell_7
Xbit_r15_c59 bl[59] br[59] wl[15] gnd reram_bitcell_7
Xbit_r16_c59 bl[59] br[59] wl[16] gnd reram_bitcell_7
Xbit_r17_c59 bl[59] br[59] wl[17] gnd reram_bitcell_7
Xbit_r18_c59 bl[59] br[59] wl[18] gnd reram_bitcell_7
Xbit_r19_c59 bl[59] br[59] wl[19] gnd reram_bitcell_7
Xbit_r20_c59 bl[59] br[59] wl[20] gnd reram_bitcell_7
Xbit_r21_c59 bl[59] br[59] wl[21] gnd reram_bitcell_7
Xbit_r22_c59 bl[59] br[59] wl[22] gnd reram_bitcell_7
Xbit_r23_c59 bl[59] br[59] wl[23] gnd reram_bitcell_7
Xbit_r24_c59 bl[59] br[59] wl[24] gnd reram_bitcell_7
Xbit_r25_c59 bl[59] br[59] wl[25] gnd reram_bitcell_7
Xbit_r26_c59 bl[59] br[59] wl[26] gnd reram_bitcell_7
Xbit_r27_c59 bl[59] br[59] wl[27] gnd reram_bitcell_7
Xbit_r28_c59 bl[59] br[59] wl[28] gnd reram_bitcell_7
Xbit_r29_c59 bl[59] br[59] wl[29] gnd reram_bitcell_7
Xbit_r30_c59 bl[59] br[59] wl[30] gnd reram_bitcell_7
Xbit_r31_c59 bl[59] br[59] wl[31] gnd reram_bitcell_7
Xbit_r0_c60 bl[60] br[60] wl[0] gnd reram_bitcell_7
Xbit_r1_c60 bl[60] br[60] wl[1] gnd reram_bitcell_7
Xbit_r2_c60 bl[60] br[60] wl[2] gnd reram_bitcell_7
Xbit_r3_c60 bl[60] br[60] wl[3] gnd reram_bitcell_7
Xbit_r4_c60 bl[60] br[60] wl[4] gnd reram_bitcell_7
Xbit_r5_c60 bl[60] br[60] wl[5] gnd reram_bitcell_7
Xbit_r6_c60 bl[60] br[60] wl[6] gnd reram_bitcell_7
Xbit_r7_c60 bl[60] br[60] wl[7] gnd reram_bitcell_7
Xbit_r8_c60 bl[60] br[60] wl[8] gnd reram_bitcell_7
Xbit_r9_c60 bl[60] br[60] wl[9] gnd reram_bitcell_7
Xbit_r10_c60 bl[60] br[60] wl[10] gnd reram_bitcell_7
Xbit_r11_c60 bl[60] br[60] wl[11] gnd reram_bitcell_7
Xbit_r12_c60 bl[60] br[60] wl[12] gnd reram_bitcell_7
Xbit_r13_c60 bl[60] br[60] wl[13] gnd reram_bitcell_7
Xbit_r14_c60 bl[60] br[60] wl[14] gnd reram_bitcell_7
Xbit_r15_c60 bl[60] br[60] wl[15] gnd reram_bitcell_7
Xbit_r16_c60 bl[60] br[60] wl[16] gnd reram_bitcell_7
Xbit_r17_c60 bl[60] br[60] wl[17] gnd reram_bitcell_7
Xbit_r18_c60 bl[60] br[60] wl[18] gnd reram_bitcell_7
Xbit_r19_c60 bl[60] br[60] wl[19] gnd reram_bitcell_7
Xbit_r20_c60 bl[60] br[60] wl[20] gnd reram_bitcell_7
Xbit_r21_c60 bl[60] br[60] wl[21] gnd reram_bitcell_7
Xbit_r22_c60 bl[60] br[60] wl[22] gnd reram_bitcell_7
Xbit_r23_c60 bl[60] br[60] wl[23] gnd reram_bitcell_7
Xbit_r24_c60 bl[60] br[60] wl[24] gnd reram_bitcell_7
Xbit_r25_c60 bl[60] br[60] wl[25] gnd reram_bitcell_7
Xbit_r26_c60 bl[60] br[60] wl[26] gnd reram_bitcell_7
Xbit_r27_c60 bl[60] br[60] wl[27] gnd reram_bitcell_7
Xbit_r28_c60 bl[60] br[60] wl[28] gnd reram_bitcell_7
Xbit_r29_c60 bl[60] br[60] wl[29] gnd reram_bitcell_7
Xbit_r30_c60 bl[60] br[60] wl[30] gnd reram_bitcell_7
Xbit_r31_c60 bl[60] br[60] wl[31] gnd reram_bitcell_7
Xbit_r0_c61 bl[61] br[61] wl[0] gnd reram_bitcell_7
Xbit_r1_c61 bl[61] br[61] wl[1] gnd reram_bitcell_7
Xbit_r2_c61 bl[61] br[61] wl[2] gnd reram_bitcell_7
Xbit_r3_c61 bl[61] br[61] wl[3] gnd reram_bitcell_7
Xbit_r4_c61 bl[61] br[61] wl[4] gnd reram_bitcell_7
Xbit_r5_c61 bl[61] br[61] wl[5] gnd reram_bitcell_7
Xbit_r6_c61 bl[61] br[61] wl[6] gnd reram_bitcell_7
Xbit_r7_c61 bl[61] br[61] wl[7] gnd reram_bitcell_7
Xbit_r8_c61 bl[61] br[61] wl[8] gnd reram_bitcell_7
Xbit_r9_c61 bl[61] br[61] wl[9] gnd reram_bitcell_7
Xbit_r10_c61 bl[61] br[61] wl[10] gnd reram_bitcell_7
Xbit_r11_c61 bl[61] br[61] wl[11] gnd reram_bitcell_7
Xbit_r12_c61 bl[61] br[61] wl[12] gnd reram_bitcell_7
Xbit_r13_c61 bl[61] br[61] wl[13] gnd reram_bitcell_7
Xbit_r14_c61 bl[61] br[61] wl[14] gnd reram_bitcell_7
Xbit_r15_c61 bl[61] br[61] wl[15] gnd reram_bitcell_7
Xbit_r16_c61 bl[61] br[61] wl[16] gnd reram_bitcell_7
Xbit_r17_c61 bl[61] br[61] wl[17] gnd reram_bitcell_7
Xbit_r18_c61 bl[61] br[61] wl[18] gnd reram_bitcell_7
Xbit_r19_c61 bl[61] br[61] wl[19] gnd reram_bitcell_7
Xbit_r20_c61 bl[61] br[61] wl[20] gnd reram_bitcell_7
Xbit_r21_c61 bl[61] br[61] wl[21] gnd reram_bitcell_7
Xbit_r22_c61 bl[61] br[61] wl[22] gnd reram_bitcell_7
Xbit_r23_c61 bl[61] br[61] wl[23] gnd reram_bitcell_7
Xbit_r24_c61 bl[61] br[61] wl[24] gnd reram_bitcell_7
Xbit_r25_c61 bl[61] br[61] wl[25] gnd reram_bitcell_7
Xbit_r26_c61 bl[61] br[61] wl[26] gnd reram_bitcell_7
Xbit_r27_c61 bl[61] br[61] wl[27] gnd reram_bitcell_7
Xbit_r28_c61 bl[61] br[61] wl[28] gnd reram_bitcell_7
Xbit_r29_c61 bl[61] br[61] wl[29] gnd reram_bitcell_7
Xbit_r30_c61 bl[61] br[61] wl[30] gnd reram_bitcell_7
Xbit_r31_c61 bl[61] br[61] wl[31] gnd reram_bitcell_7
Xbit_r0_c62 bl[62] br[62] wl[0] gnd reram_bitcell_7
Xbit_r1_c62 bl[62] br[62] wl[1] gnd reram_bitcell_7
Xbit_r2_c62 bl[62] br[62] wl[2] gnd reram_bitcell_7
Xbit_r3_c62 bl[62] br[62] wl[3] gnd reram_bitcell_7
Xbit_r4_c62 bl[62] br[62] wl[4] gnd reram_bitcell_7
Xbit_r5_c62 bl[62] br[62] wl[5] gnd reram_bitcell_7
Xbit_r6_c62 bl[62] br[62] wl[6] gnd reram_bitcell_7
Xbit_r7_c62 bl[62] br[62] wl[7] gnd reram_bitcell_7
Xbit_r8_c62 bl[62] br[62] wl[8] gnd reram_bitcell_7
Xbit_r9_c62 bl[62] br[62] wl[9] gnd reram_bitcell_7
Xbit_r10_c62 bl[62] br[62] wl[10] gnd reram_bitcell_7
Xbit_r11_c62 bl[62] br[62] wl[11] gnd reram_bitcell_7
Xbit_r12_c62 bl[62] br[62] wl[12] gnd reram_bitcell_7
Xbit_r13_c62 bl[62] br[62] wl[13] gnd reram_bitcell_7
Xbit_r14_c62 bl[62] br[62] wl[14] gnd reram_bitcell_7
Xbit_r15_c62 bl[62] br[62] wl[15] gnd reram_bitcell_7
Xbit_r16_c62 bl[62] br[62] wl[16] gnd reram_bitcell_7
Xbit_r17_c62 bl[62] br[62] wl[17] gnd reram_bitcell_7
Xbit_r18_c62 bl[62] br[62] wl[18] gnd reram_bitcell_7
Xbit_r19_c62 bl[62] br[62] wl[19] gnd reram_bitcell_7
Xbit_r20_c62 bl[62] br[62] wl[20] gnd reram_bitcell_7
Xbit_r21_c62 bl[62] br[62] wl[21] gnd reram_bitcell_7
Xbit_r22_c62 bl[62] br[62] wl[22] gnd reram_bitcell_7
Xbit_r23_c62 bl[62] br[62] wl[23] gnd reram_bitcell_7
Xbit_r24_c62 bl[62] br[62] wl[24] gnd reram_bitcell_7
Xbit_r25_c62 bl[62] br[62] wl[25] gnd reram_bitcell_7
Xbit_r26_c62 bl[62] br[62] wl[26] gnd reram_bitcell_7
Xbit_r27_c62 bl[62] br[62] wl[27] gnd reram_bitcell_7
Xbit_r28_c62 bl[62] br[62] wl[28] gnd reram_bitcell_7
Xbit_r29_c62 bl[62] br[62] wl[29] gnd reram_bitcell_7
Xbit_r30_c62 bl[62] br[62] wl[30] gnd reram_bitcell_7
Xbit_r31_c62 bl[62] br[62] wl[31] gnd reram_bitcell_7
Xbit_r0_c63 bl[63] br[63] wl[0] gnd reram_bitcell_7
Xbit_r1_c63 bl[63] br[63] wl[1] gnd reram_bitcell_7
Xbit_r2_c63 bl[63] br[63] wl[2] gnd reram_bitcell_7
Xbit_r3_c63 bl[63] br[63] wl[3] gnd reram_bitcell_7
Xbit_r4_c63 bl[63] br[63] wl[4] gnd reram_bitcell_7
Xbit_r5_c63 bl[63] br[63] wl[5] gnd reram_bitcell_7
Xbit_r6_c63 bl[63] br[63] wl[6] gnd reram_bitcell_7
Xbit_r7_c63 bl[63] br[63] wl[7] gnd reram_bitcell_7
Xbit_r8_c63 bl[63] br[63] wl[8] gnd reram_bitcell_7
Xbit_r9_c63 bl[63] br[63] wl[9] gnd reram_bitcell_7
Xbit_r10_c63 bl[63] br[63] wl[10] gnd reram_bitcell_7
Xbit_r11_c63 bl[63] br[63] wl[11] gnd reram_bitcell_7
Xbit_r12_c63 bl[63] br[63] wl[12] gnd reram_bitcell_7
Xbit_r13_c63 bl[63] br[63] wl[13] gnd reram_bitcell_7
Xbit_r14_c63 bl[63] br[63] wl[14] gnd reram_bitcell_7
Xbit_r15_c63 bl[63] br[63] wl[15] gnd reram_bitcell_7
Xbit_r16_c63 bl[63] br[63] wl[16] gnd reram_bitcell_7
Xbit_r17_c63 bl[63] br[63] wl[17] gnd reram_bitcell_7
Xbit_r18_c63 bl[63] br[63] wl[18] gnd reram_bitcell_7
Xbit_r19_c63 bl[63] br[63] wl[19] gnd reram_bitcell_7
Xbit_r20_c63 bl[63] br[63] wl[20] gnd reram_bitcell_7
Xbit_r21_c63 bl[63] br[63] wl[21] gnd reram_bitcell_7
Xbit_r22_c63 bl[63] br[63] wl[22] gnd reram_bitcell_7
Xbit_r23_c63 bl[63] br[63] wl[23] gnd reram_bitcell_7
Xbit_r24_c63 bl[63] br[63] wl[24] gnd reram_bitcell_7
Xbit_r25_c63 bl[63] br[63] wl[25] gnd reram_bitcell_7
Xbit_r26_c63 bl[63] br[63] wl[26] gnd reram_bitcell_7
Xbit_r27_c63 bl[63] br[63] wl[27] gnd reram_bitcell_7
Xbit_r28_c63 bl[63] br[63] wl[28] gnd reram_bitcell_7
Xbit_r29_c63 bl[63] br[63] wl[29] gnd reram_bitcell_7
Xbit_r30_c63 bl[63] br[63] wl[30] gnd reram_bitcell_7
Xbit_r31_c63 bl[63] br[63] wl[31] gnd reram_bitcell_7
.ENDS bitcell_array

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=4 w=2.88 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=4 w=7.2 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT tri_state_4 in_bar out en en_bar vdd gnd
Xnmos0 gnd en left_mid_n gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos1 left_mid_n in_bar out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos2 gnd en right_mid_n gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos3 right_mid_n in_bar out gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xpmos0 vdd en_bar left_mid_p vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos1 left_mid_p in_bar out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos2 vdd en_bar right_mid_p vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos3 right_mid_p in_bar out vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
.ENDS tri_state_4

.SUBCKT tri_gate_array in_bar[0] in_bar[1] in_bar[2] in_bar[3] in_bar[4] in_bar[5] in_bar[6] in_bar[7] in_bar[8] in_bar[9] in_bar[10] in_bar[11] in_bar[12] in_bar[13] in_bar[14] in_bar[15] in_bar[16] in_bar[17] in_bar[18] in_bar[19] in_bar[20] in_bar[21] in_bar[22] in_bar[23] in_bar[24] in_bar[25] in_bar[26] in_bar[27] in_bar[28] in_bar[29] in_bar[30] in_bar[31] in_bar[32] in_bar[33] in_bar[34] in_bar[35] in_bar[36] in_bar[37] in_bar[38] in_bar[39] in_bar[40] in_bar[41] in_bar[42] in_bar[43] in_bar[44] in_bar[45] in_bar[46] in_bar[47] in_bar[48] in_bar[49] in_bar[50] in_bar[51] in_bar[52] in_bar[53] in_bar[54] in_bar[55] in_bar[56] in_bar[57] in_bar[58] in_bar[59] in_bar[60] in_bar[61] in_bar[62] in_bar[63] out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] out[8] out[9] out[10] out[11] out[12] out[13] out[14] out[15] out[16] out[17] out[18] out[19] out[20] out[21] out[22] out[23] out[24] out[25] out[26] out[27] out[28] out[29] out[30] out[31] out[32] out[33] out[34] out[35] out[36] out[37] out[38] out[39] out[40] out[41] out[42] out[43] out[44] out[45] out[46] out[47] out[48] out[49] out[50] out[51] out[52] out[53] out[54] out[55] out[56] out[57] out[58] out[59] out[60] out[61] out[62] out[63] en en_bar vdd gnd
Xmod_0 in_bar[0] out[0] en en_bar vdd gnd tri_state_4
Xmod_1 in_bar[1] out[1] en en_bar vdd gnd tri_state_4
Xmod_2 in_bar[2] out[2] en en_bar vdd gnd tri_state_4
Xmod_3 in_bar[3] out[3] en en_bar vdd gnd tri_state_4
Xmod_4 in_bar[4] out[4] en en_bar vdd gnd tri_state_4
Xmod_5 in_bar[5] out[5] en en_bar vdd gnd tri_state_4
Xmod_6 in_bar[6] out[6] en en_bar vdd gnd tri_state_4
Xmod_7 in_bar[7] out[7] en en_bar vdd gnd tri_state_4
Xmod_8 in_bar[8] out[8] en en_bar vdd gnd tri_state_4
Xmod_9 in_bar[9] out[9] en en_bar vdd gnd tri_state_4
Xmod_10 in_bar[10] out[10] en en_bar vdd gnd tri_state_4
Xmod_11 in_bar[11] out[11] en en_bar vdd gnd tri_state_4
Xmod_12 in_bar[12] out[12] en en_bar vdd gnd tri_state_4
Xmod_13 in_bar[13] out[13] en en_bar vdd gnd tri_state_4
Xmod_14 in_bar[14] out[14] en en_bar vdd gnd tri_state_4
Xmod_15 in_bar[15] out[15] en en_bar vdd gnd tri_state_4
Xmod_16 in_bar[16] out[16] en en_bar vdd gnd tri_state_4
Xmod_17 in_bar[17] out[17] en en_bar vdd gnd tri_state_4
Xmod_18 in_bar[18] out[18] en en_bar vdd gnd tri_state_4
Xmod_19 in_bar[19] out[19] en en_bar vdd gnd tri_state_4
Xmod_20 in_bar[20] out[20] en en_bar vdd gnd tri_state_4
Xmod_21 in_bar[21] out[21] en en_bar vdd gnd tri_state_4
Xmod_22 in_bar[22] out[22] en en_bar vdd gnd tri_state_4
Xmod_23 in_bar[23] out[23] en en_bar vdd gnd tri_state_4
Xmod_24 in_bar[24] out[24] en en_bar vdd gnd tri_state_4
Xmod_25 in_bar[25] out[25] en en_bar vdd gnd tri_state_4
Xmod_26 in_bar[26] out[26] en en_bar vdd gnd tri_state_4
Xmod_27 in_bar[27] out[27] en en_bar vdd gnd tri_state_4
Xmod_28 in_bar[28] out[28] en en_bar vdd gnd tri_state_4
Xmod_29 in_bar[29] out[29] en en_bar vdd gnd tri_state_4
Xmod_30 in_bar[30] out[30] en en_bar vdd gnd tri_state_4
Xmod_31 in_bar[31] out[31] en en_bar vdd gnd tri_state_4
Xmod_32 in_bar[32] out[32] en en_bar vdd gnd tri_state_4
Xmod_33 in_bar[33] out[33] en en_bar vdd gnd tri_state_4
Xmod_34 in_bar[34] out[34] en en_bar vdd gnd tri_state_4
Xmod_35 in_bar[35] out[35] en en_bar vdd gnd tri_state_4
Xmod_36 in_bar[36] out[36] en en_bar vdd gnd tri_state_4
Xmod_37 in_bar[37] out[37] en en_bar vdd gnd tri_state_4
Xmod_38 in_bar[38] out[38] en en_bar vdd gnd tri_state_4
Xmod_39 in_bar[39] out[39] en en_bar vdd gnd tri_state_4
Xmod_40 in_bar[40] out[40] en en_bar vdd gnd tri_state_4
Xmod_41 in_bar[41] out[41] en en_bar vdd gnd tri_state_4
Xmod_42 in_bar[42] out[42] en en_bar vdd gnd tri_state_4
Xmod_43 in_bar[43] out[43] en en_bar vdd gnd tri_state_4
Xmod_44 in_bar[44] out[44] en en_bar vdd gnd tri_state_4
Xmod_45 in_bar[45] out[45] en en_bar vdd gnd tri_state_4
Xmod_46 in_bar[46] out[46] en en_bar vdd gnd tri_state_4
Xmod_47 in_bar[47] out[47] en en_bar vdd gnd tri_state_4
Xmod_48 in_bar[48] out[48] en en_bar vdd gnd tri_state_4
Xmod_49 in_bar[49] out[49] en en_bar vdd gnd tri_state_4
Xmod_50 in_bar[50] out[50] en en_bar vdd gnd tri_state_4
Xmod_51 in_bar[51] out[51] en en_bar vdd gnd tri_state_4
Xmod_52 in_bar[52] out[52] en en_bar vdd gnd tri_state_4
Xmod_53 in_bar[53] out[53] en en_bar vdd gnd tri_state_4
Xmod_54 in_bar[54] out[54] en en_bar vdd gnd tri_state_4
Xmod_55 in_bar[55] out[55] en en_bar vdd gnd tri_state_4
Xmod_56 in_bar[56] out[56] en en_bar vdd gnd tri_state_4
Xmod_57 in_bar[57] out[57] en en_bar vdd gnd tri_state_4
Xmod_58 in_bar[58] out[58] en en_bar vdd gnd tri_state_4
Xmod_59 in_bar[59] out[59] en en_bar vdd gnd tri_state_4
Xmod_60 in_bar[60] out[60] en en_bar vdd gnd tri_state_4
Xmod_61 in_bar[61] out[61] en en_bar vdd gnd tri_state_4
Xmod_62 in_bar[62] out[62] en en_bar vdd gnd tri_state_4
Xmod_63 in_bar[63] out[63] en en_bar vdd gnd tri_state_4
.ENDS tri_gate_array
.subckt re_ram_sense_amp bl br dout dout_bar en gnd sampleb vclamp vclampp vdd vref
xm1 vdata vclamp bl gnd sky130_fd_pr__nfet_01v8 l=0.15 w=1.44 nf=4
+ sa=0 sb=0 sd=0 mult=1 m=1
xm2 vdata vclampp net1 vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 net1 sampleb vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 net3 vdata net2 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 dout vref net2 gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 net2 en gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=1.2 nf=2
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout net3 vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.2 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm8 net3 net3 vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.2 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm9 dout_bar dout gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.72 nf=2
+   sa=0 sb=0 sd=0 mult=1 m=1
xm10 dout_bar dout vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.44 nf=2
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

.SUBCKT sense_amp_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] bl[32] bl[33] bl[34] bl[35] bl[36] bl[37] bl[38] bl[39] bl[40] bl[41] bl[42] bl[43] bl[44] bl[45] bl[46] bl[47] bl[48] bl[49] bl[50] bl[51] bl[52] bl[53] bl[54] bl[55] bl[56] bl[57] bl[58] bl[59] bl[60] bl[61] bl[62] bl[63] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] br[32] br[33] br[34] br[35] br[36] br[37] br[38] br[39] br[40] br[41] br[42] br[43] br[44] br[45] br[46] br[47] br[48] br[49] br[50] br[51] br[52] br[53] br[54] br[55] br[56] br[57] br[58] br[59] br[60] br[61] br[62] br[63] dout[0] dout[1] dout[2] dout[3] dout[4] dout[5] dout[6] dout[7] dout[8] dout[9] dout[10] dout[11] dout[12] dout[13] dout[14] dout[15] dout[16] dout[17] dout[18] dout[19] dout[20] dout[21] dout[22] dout[23] dout[24] dout[25] dout[26] dout[27] dout[28] dout[29] dout[30] dout[31] dout[32] dout[33] dout[34] dout[35] dout[36] dout[37] dout[38] dout[39] dout[40] dout[41] dout[42] dout[43] dout[44] dout[45] dout[46] dout[47] dout[48] dout[49] dout[50] dout[51] dout[52] dout[53] dout[54] dout[55] dout[56] dout[57] dout[58] dout[59] dout[60] dout[61] dout[62] dout[63] dout_bar[0] dout_bar[1] dout_bar[2] dout_bar[3] dout_bar[4] dout_bar[5] dout_bar[6] dout_bar[7] dout_bar[8] dout_bar[9] dout_bar[10] dout_bar[11] dout_bar[12] dout_bar[13] dout_bar[14] dout_bar[15] dout_bar[16] dout_bar[17] dout_bar[18] dout_bar[19] dout_bar[20] dout_bar[21] dout_bar[22] dout_bar[23] dout_bar[24] dout_bar[25] dout_bar[26] dout_bar[27] dout_bar[28] dout_bar[29] dout_bar[30] dout_bar[31] dout_bar[32] dout_bar[33] dout_bar[34] dout_bar[35] dout_bar[36] dout_bar[37] dout_bar[38] dout_bar[39] dout_bar[40] dout_bar[41] dout_bar[42] dout_bar[43] dout_bar[44] dout_bar[45] dout_bar[46] dout_bar[47] dout_bar[48] dout_bar[49] dout_bar[50] dout_bar[51] dout_bar[52] dout_bar[53] dout_bar[54] dout_bar[55] dout_bar[56] dout_bar[57] dout_bar[58] dout_bar[59] dout_bar[60] dout_bar[61] dout_bar[62] dout_bar[63] en gnd sampleb vclamp vclampp vdd vref
Xmod_0 bl[0] br[0] dout[0] dout_bar[0] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_1 bl[1] br[1] dout[1] dout_bar[1] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_2 bl[2] br[2] dout[2] dout_bar[2] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_3 bl[3] br[3] dout[3] dout_bar[3] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_4 bl[4] br[4] dout[4] dout_bar[4] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_5 bl[5] br[5] dout[5] dout_bar[5] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_6 bl[6] br[6] dout[6] dout_bar[6] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_7 bl[7] br[7] dout[7] dout_bar[7] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_8 bl[8] br[8] dout[8] dout_bar[8] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_9 bl[9] br[9] dout[9] dout_bar[9] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_10 bl[10] br[10] dout[10] dout_bar[10] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_11 bl[11] br[11] dout[11] dout_bar[11] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_12 bl[12] br[12] dout[12] dout_bar[12] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_13 bl[13] br[13] dout[13] dout_bar[13] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_14 bl[14] br[14] dout[14] dout_bar[14] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_15 bl[15] br[15] dout[15] dout_bar[15] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_16 bl[16] br[16] dout[16] dout_bar[16] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_17 bl[17] br[17] dout[17] dout_bar[17] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_18 bl[18] br[18] dout[18] dout_bar[18] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_19 bl[19] br[19] dout[19] dout_bar[19] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_20 bl[20] br[20] dout[20] dout_bar[20] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_21 bl[21] br[21] dout[21] dout_bar[21] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_22 bl[22] br[22] dout[22] dout_bar[22] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_23 bl[23] br[23] dout[23] dout_bar[23] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_24 bl[24] br[24] dout[24] dout_bar[24] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_25 bl[25] br[25] dout[25] dout_bar[25] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_26 bl[26] br[26] dout[26] dout_bar[26] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_27 bl[27] br[27] dout[27] dout_bar[27] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_28 bl[28] br[28] dout[28] dout_bar[28] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_29 bl[29] br[29] dout[29] dout_bar[29] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_30 bl[30] br[30] dout[30] dout_bar[30] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_31 bl[31] br[31] dout[31] dout_bar[31] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_32 bl[32] br[32] dout[32] dout_bar[32] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_33 bl[33] br[33] dout[33] dout_bar[33] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_34 bl[34] br[34] dout[34] dout_bar[34] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_35 bl[35] br[35] dout[35] dout_bar[35] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_36 bl[36] br[36] dout[36] dout_bar[36] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_37 bl[37] br[37] dout[37] dout_bar[37] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_38 bl[38] br[38] dout[38] dout_bar[38] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_39 bl[39] br[39] dout[39] dout_bar[39] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_40 bl[40] br[40] dout[40] dout_bar[40] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_41 bl[41] br[41] dout[41] dout_bar[41] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_42 bl[42] br[42] dout[42] dout_bar[42] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_43 bl[43] br[43] dout[43] dout_bar[43] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_44 bl[44] br[44] dout[44] dout_bar[44] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_45 bl[45] br[45] dout[45] dout_bar[45] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_46 bl[46] br[46] dout[46] dout_bar[46] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_47 bl[47] br[47] dout[47] dout_bar[47] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_48 bl[48] br[48] dout[48] dout_bar[48] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_49 bl[49] br[49] dout[49] dout_bar[49] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_50 bl[50] br[50] dout[50] dout_bar[50] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_51 bl[51] br[51] dout[51] dout_bar[51] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_52 bl[52] br[52] dout[52] dout_bar[52] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_53 bl[53] br[53] dout[53] dout_bar[53] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_54 bl[54] br[54] dout[54] dout_bar[54] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_55 bl[55] br[55] dout[55] dout_bar[55] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_56 bl[56] br[56] dout[56] dout_bar[56] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_57 bl[57] br[57] dout[57] dout_bar[57] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_58 bl[58] br[58] dout[58] dout_bar[58] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_59 bl[59] br[59] dout[59] dout_bar[59] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_60 bl[60] br[60] dout[60] dout_bar[60] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_61 bl[61] br[61] dout[61] dout_bar[61] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_62 bl[62] br[62] dout[62] dout_bar[62] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
Xmod_63 bl[63] br[63] dout[63] dout_bar[63] en gnd sampleb vclamp vclampp vdd vref re_ram_sense_amp
.ENDS sense_amp_array

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375

.SUBCKT pinv_1_no_p_no_n_align_same_line A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1_no_p_no_n_align_same_line

.SUBCKT pnand2_1_no_p_no_n_align_same_line A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pnand2_1_no_p_no_n_align_same_line

.SUBCKT pnand3_1_no_p_no_n_align_same_line A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pnand3_1_no_p_no_n_align_same_line
.subckt ms_flop_horz_pitch din dout dout_bar clk vdd gnd
xm1 clk_buf clk_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 clk_buf clk_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 clk_bar clk gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm3 clk_bar clk vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.9 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
x1 din clk_buf vdd gnd lout lout_bar clk_bar dlatch
x2 lout_bar clk_bar vdd gnd dout_bar dout clk_buf dlatch
.ends
.subckt dlatch  din clk vdd gnd dout dout_bar clk_bar
xm1 dout dout_bar gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm2 dout_bar int gnd gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.61 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm3 int clk dout gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm5 int clk_bar dout vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm4 int clk_bar din gnd sky130_fd_pr__nfet_01v8 l=0.15 w=0.36 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm6 int clk din vdd sky130_fd_pr__pfet_01v8 l=0.15 w=0.6 nf=1
+ sa=0 sb=0 sd=0 mult=1 m=1
xm7 dout_bar int vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
xm8 dout dout_bar vdd vdd sky130_fd_pr__pfet_01v8 l=0.15 w=1.22 nf=1
+   sa=0 sb=0 sd=0 mult=1 m=1
.ends

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.5999999999999996 l=0.15 pd=2.6999999999999997 ps=2.6999999999999997 as=0.44999999999999996 ad=0.44999999999999996

.SUBCKT pinv_4_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.5999999999999996 l=0.15 pd=2.6999999999999997 ps=2.6999999999999997 as=0.44999999999999996 ad=0.44999999999999996
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.44 l=0.15 pd=1.26 ps=1.26 as=0.18 ad=0.18
.ENDS pinv_4_h_3__2

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.86 l=0.15 pd=2.02 ps=2.02 as=0.3225 ad=0.3225

.SUBCKT pnand2_1__06_no_p_no_n_h_3__2 A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.86 l=0.15 pd=2.02 ps=2.02 as=0.3225 ad=0.3225
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.86 l=0.15 pd=2.02 ps=2.02 as=0.3225 ad=0.3225
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.6900000000000001 l=0.15 pd=1.6800000000000002 ps=1.6800000000000002 as=0.25875000000000004 ad=0.25875000000000004
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.6900000000000001 l=0.15 pd=1.6800000000000002 ps=1.6800000000000002 as=0.25875000000000004 ad=0.25875000000000004
.ENDS pnand2_1__06_no_p_no_n_h_3__2

.SUBCKT buffer_stage_4_no_out_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_4_h_3__2
.ENDS buffer_stage_4_no_out_h_3__2

.SUBCKT pinv_4_no_p_no_n_h_3__2 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=3.5999999999999996 l=0.15 pd=2.6999999999999997 ps=2.6999999999999997 as=0.44999999999999996 ad=0.44999999999999996
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.44 l=0.15 pd=1.26 ps=1.26 as=0.18 ad=0.18
.ENDS pinv_4_no_p_no_n_h_3__2

.SUBCKT buffer_stage_4_no_out_no_nwell_cont_no_pwell_cont_h_3__2 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_4_no_p_no_n_h_3__2
.ENDS buffer_stage_4_no_out_no_nwell_cont_no_pwell_cont_h_3__2

.SUBCKT pre2x4_no_top_flops flop_in[0] flop_in[1] out[0] out[1] out[2] out[3] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_4_no_out_no_nwell_cont_no_pwell_cont_h_3__2
Xpre2x4_nand_0 inbar[0] inbar[1] Z[0] vdd gnd pnand2_1__06_no_p_no_n_h_3__2
Xpre2x4_nand_1 in[0] inbar[1] Z[1] vdd gnd pnand2_1__06_no_p_no_n_h_3__2
Xpre2x4_nand_2 inbar[0] in[1] Z[2] vdd gnd pnand2_1__06_no_p_no_n_h_3__2
Xpre2x4_nand_3 in[0] in[1] Z[3] vdd gnd pnand2_1__06_no_p_no_n_h_3__2
.ENDS pre2x4_no_top_flops

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.63 l=0.15 pd=1.56 ps=1.56 as=0.23625000000000002 ad=0.23625000000000002

.SUBCKT pnand3_1_no_p_no_n_h_3__2 A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.63 l=0.15 pd=1.56 ps=1.56 as=0.23625000000000002 ad=0.23625000000000002
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.63 l=0.15 pd=1.56 ps=1.56 as=0.23625000000000002 ad=0.23625000000000002
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.63 l=0.15 pd=1.56 ps=1.56 as=0.23625000000000002 ad=0.23625000000000002
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.63 l=0.15 pd=1.56 ps=1.56 as=0.23625000000000002 ad=0.23625000000000002
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.63 l=0.15 pd=1.56 ps=1.56 as=0.23625000000000002 ad=0.23625000000000002
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.63 l=0.15 pd=1.56 ps=1.56 as=0.23625000000000002 ad=0.23625000000000002
.ENDS pnand3_1_no_p_no_n_h_3__2

.SUBCKT pre3x8_no_top_flops flop_in[0] flop_in[1] flop_in[2] out[0] out[1] out[2] out[3] out[4] out[5] out[6] out[7] clk vdd gnd
Xflop_0 flop_in[0] in[0] inbar[0] clk vdd gnd ms_flop_horz_pitch
Xflop_1 flop_in[1] in[1] inbar[1] clk vdd gnd ms_flop_horz_pitch
Xflop_2 flop_in[2] in[2] inbar[2] clk vdd gnd ms_flop_horz_pitch
Xpre_nand_inv_0 Z[0] out[0] Z[0] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_1 Z[1] out[1] Z[1] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_2 Z[2] out[2] Z[2] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_3 Z[3] out[3] Z[3] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_4 Z[4] out[4] Z[4] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_5 Z[5] out[5] Z[5] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_6 Z[6] out[6] Z[6] vdd gnd buffer_stage_4_no_out_h_3__2
Xpre_nand_inv_7 Z[7] out[7] Z[7] vdd gnd buffer_stage_4_no_out_no_nwell_cont_no_pwell_cont_h_3__2
Xpre3x8_nand_0 inbar[0] inbar[1] inbar[2] Z[0] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_1 in[0] inbar[1] inbar[2] Z[1] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_2 inbar[0] in[1] inbar[2] Z[2] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_3 in[0] in[1] inbar[2] Z[3] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_4 inbar[0] inbar[1] in[2] Z[4] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_5 in[0] inbar[1] in[2] Z[5] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_6 inbar[0] in[1] in[2] Z[6] vdd gnd pnand3_1_no_p_no_n_h_3__2
Xpre3x8_nand_7 in[0] in[1] in[2] Z[7] vdd gnd pnand3_1_no_p_no_n_h_3__2
.ENDS pre3x8_no_top_flops

.SUBCKT hierarchical_decoder_32rows A[0] A[1] A[2] A[3] A[4] decode[0] decode[1] decode[2] decode[3] decode[4] decode[5] decode[6] decode[7] decode[8] decode[9] decode[10] decode[11] decode[12] decode[13] decode[14] decode[15] decode[16] decode[17] decode[18] decode[19] decode[20] decode[21] decode[22] decode[23] decode[24] decode[25] decode[26] decode[27] decode[28] decode[29] decode[30] decode[31] clk vdd gnd
Xpre_0 A[0] A[1] out[0] out[1] out[2] out[3] clk vdd gnd pre2x4_no_top_flops
Xpre_1 A[2] A[3] A[4] out[4] out[5] out[6] out[7] out[8] out[9] out[10] out[11] clk vdd gnd pre3x8_no_top_flops
XDEC_NAND[0] out[0] out[4] Z[0] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[1] out[1] out[4] Z[1] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[2] out[2] out[4] Z[2] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[3] out[3] out[4] Z[3] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[4] out[0] out[5] Z[4] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[5] out[1] out[5] Z[5] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[6] out[2] out[5] Z[6] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[7] out[3] out[5] Z[7] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[8] out[0] out[6] Z[8] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[9] out[1] out[6] Z[9] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[10] out[2] out[6] Z[10] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[11] out[3] out[6] Z[11] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[12] out[0] out[7] Z[12] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[13] out[1] out[7] Z[13] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[14] out[2] out[7] Z[14] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[15] out[3] out[7] Z[15] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[16] out[0] out[8] Z[16] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[17] out[1] out[8] Z[17] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[18] out[2] out[8] Z[18] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[19] out[3] out[8] Z[19] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[20] out[0] out[9] Z[20] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[21] out[1] out[9] Z[21] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[22] out[2] out[9] Z[22] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[23] out[3] out[9] Z[23] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[24] out[0] out[10] Z[24] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[25] out[1] out[10] Z[25] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[26] out[2] out[10] Z[26] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[27] out[3] out[10] Z[27] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[28] out[0] out[11] Z[28] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[29] out[1] out[11] Z[29] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[30] out[2] out[11] Z[30] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_NAND[31] out[3] out[11] Z[31] vdd gnd pnand2_1_no_p_no_n_align_same_line
XDEC_INV_[0] Z[0] decode[0] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[1] Z[1] decode[1] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[2] Z[2] decode[2] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[3] Z[3] decode[3] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[4] Z[4] decode[4] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[5] Z[5] decode[5] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[6] Z[6] decode[6] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[7] Z[7] decode[7] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[8] Z[8] decode[8] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[9] Z[9] decode[9] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[10] Z[10] decode[10] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[11] Z[11] decode[11] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[12] Z[12] decode[12] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[13] Z[13] decode[13] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[14] Z[14] decode[14] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[15] Z[15] decode[15] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[16] Z[16] decode[16] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[17] Z[17] decode[17] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[18] Z[18] decode[18] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[19] Z[19] decode[19] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[20] Z[20] decode[20] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[21] Z[21] decode[21] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[22] Z[22] decode[22] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[23] Z[23] decode[23] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[24] Z[24] decode[24] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[25] Z[25] decode[25] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[26] Z[26] decode[26] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[27] Z[27] decode[27] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[28] Z[28] decode[28] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[29] Z[29] decode[29] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[30] Z[30] decode[30] vdd gnd pinv_1_no_p_no_n_align_same_line
XDEC_INV_[31] Z[31] decode[31] vdd gnd pinv_1_no_p_no_n_align_same_line
.ENDS hierarchical_decoder_32rows

.SUBCKT pinv_1_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1_no_p_no_n_align

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=4.5 l=0.15 pd=4.8 ps=4.8 as=0.84375 ad=0.84375

.SUBCKT pinv_5_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=4.5 l=0.15 pd=4.8 ps=4.8 as=0.84375 ad=0.84375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.8 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pinv_5_no_p_no_n_align

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=17.99 l=0.15 pd=5.4399999999999995 ps=5.4399999999999995 as=0.9637499999999999 ad=0.9637499999999999

.SUBCKT pinv_20_no_p_no_n_align A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=17.99 l=0.15 pd=5.4399999999999995 ps=5.4399999999999995 as=0.9637499999999999 ad=0.9637499999999999
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=7.21 l=0.15 pd=2.36 ps=2.36 as=0.38625 ad=0.38625
.ENDS pinv_20_no_p_no_n_align

.SUBCKT buffer_stage_1_5_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_1_no_p_no_n_align
Xinv1 out_1 out vdd gnd pinv_5_no_p_no_n_align
Xinv2 out out_inv vdd gnd pinv_20_no_p_no_n_align
.ENDS buffer_stage_1_5_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align

.SUBCKT logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnand2_1_no_p_no_n_align_same_line
Xbuffer logic_out out out_inv vdd gnd buffer_stage_1_5_20_no_out_no_nwell_cont_no_pwell_cont_h_5_align
.ENDS logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align

.SUBCKT wordline_driver_array in[0] in[1] in[2] in[3] in[4] in[5] in[6] in[7] in[8] in[9] in[10] in[11] in[12] in[13] in[14] in[15] in[16] in[17] in[18] in[19] in[20] in[21] in[22] in[23] in[24] in[25] in[26] in[27] in[28] in[29] in[30] in[31] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] en vdd gnd
Xdriver0 en in[0] wl_bar[0] wl[0] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver1 en in[1] wl_bar[1] wl[1] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver2 en in[2] wl_bar[2] wl[2] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver3 en in[3] wl_bar[3] wl[3] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver4 en in[4] wl_bar[4] wl[4] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver5 en in[5] wl_bar[5] wl[5] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver6 en in[6] wl_bar[6] wl[6] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver7 en in[7] wl_bar[7] wl[7] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver8 en in[8] wl_bar[8] wl[8] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver9 en in[9] wl_bar[9] wl[9] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver10 en in[10] wl_bar[10] wl[10] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver11 en in[11] wl_bar[11] wl[11] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver12 en in[12] wl_bar[12] wl[12] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver13 en in[13] wl_bar[13] wl[13] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver14 en in[14] wl_bar[14] wl[14] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver15 en in[15] wl_bar[15] wl[15] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver16 en in[16] wl_bar[16] wl[16] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver17 en in[17] wl_bar[17] wl[17] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver18 en in[18] wl_bar[18] wl[18] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver19 en in[19] wl_bar[19] wl[19] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver20 en in[20] wl_bar[20] wl[20] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver21 en in[21] wl_bar[21] wl[21] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver22 en in[22] wl_bar[22] wl[22] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver23 en in[23] wl_bar[23] wl[23] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver24 en in[24] wl_bar[24] wl[24] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver25 en in[25] wl_bar[25] wl[25] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver26 en in[26] wl_bar[26] wl[26] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver27 en in[27] wl_bar[27] wl[27] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver28 en in[28] wl_bar[28] wl[28] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver29 en in[29] wl_bar[29] wl[29] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver30 en in[30] wl_bar[30] wl[30] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
Xdriver31 en in[31] wl_bar[31] wl[31] vdd gnd logic_buffer_pnand2_1_5_20_no_in_no_out_no_nwell_cont_no_pwell_cont_h_5_align
.ENDS wordline_driver_array

* ptx X{0} {1} sky130_fd_pr__nfet_01v8 m=1 nf=2 w=2.16 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405

.SUBCKT discharge_6 bl br bl_reset br_reset gnd
Xbl_inst bl bl_reset gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=2.16 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405
Xbr_inst br br_reset gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=2.16 l=0.15 pd=2.46 ps=2.46 as=0.405 ad=0.405
.ENDS discharge_6

.SUBCKT precharge_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] bl[32] bl[33] bl[34] bl[35] bl[36] bl[37] bl[38] bl[39] bl[40] bl[41] bl[42] bl[43] bl[44] bl[45] bl[46] bl[47] bl[48] bl[49] bl[50] bl[51] bl[52] bl[53] bl[54] bl[55] bl[56] bl[57] bl[58] bl[59] bl[60] bl[61] bl[62] bl[63] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] br[32] br[33] br[34] br[35] br[36] br[37] br[38] br[39] br[40] br[41] br[42] br[43] br[44] br[45] br[46] br[47] br[48] br[49] br[50] br[51] br[52] br[53] br[54] br[55] br[56] br[57] br[58] br[59] br[60] br[61] br[62] br[63] bl_reset br_reset gnd
Xmod_0 bl[0] br[0] bl_reset br_reset gnd discharge_6
Xmod_1 bl[1] br[1] bl_reset br_reset gnd discharge_6
Xmod_2 bl[2] br[2] bl_reset br_reset gnd discharge_6
Xmod_3 bl[3] br[3] bl_reset br_reset gnd discharge_6
Xmod_4 bl[4] br[4] bl_reset br_reset gnd discharge_6
Xmod_5 bl[5] br[5] bl_reset br_reset gnd discharge_6
Xmod_6 bl[6] br[6] bl_reset br_reset gnd discharge_6
Xmod_7 bl[7] br[7] bl_reset br_reset gnd discharge_6
Xmod_8 bl[8] br[8] bl_reset br_reset gnd discharge_6
Xmod_9 bl[9] br[9] bl_reset br_reset gnd discharge_6
Xmod_10 bl[10] br[10] bl_reset br_reset gnd discharge_6
Xmod_11 bl[11] br[11] bl_reset br_reset gnd discharge_6
Xmod_12 bl[12] br[12] bl_reset br_reset gnd discharge_6
Xmod_13 bl[13] br[13] bl_reset br_reset gnd discharge_6
Xmod_14 bl[14] br[14] bl_reset br_reset gnd discharge_6
Xmod_15 bl[15] br[15] bl_reset br_reset gnd discharge_6
Xmod_16 bl[16] br[16] bl_reset br_reset gnd discharge_6
Xmod_17 bl[17] br[17] bl_reset br_reset gnd discharge_6
Xmod_18 bl[18] br[18] bl_reset br_reset gnd discharge_6
Xmod_19 bl[19] br[19] bl_reset br_reset gnd discharge_6
Xmod_20 bl[20] br[20] bl_reset br_reset gnd discharge_6
Xmod_21 bl[21] br[21] bl_reset br_reset gnd discharge_6
Xmod_22 bl[22] br[22] bl_reset br_reset gnd discharge_6
Xmod_23 bl[23] br[23] bl_reset br_reset gnd discharge_6
Xmod_24 bl[24] br[24] bl_reset br_reset gnd discharge_6
Xmod_25 bl[25] br[25] bl_reset br_reset gnd discharge_6
Xmod_26 bl[26] br[26] bl_reset br_reset gnd discharge_6
Xmod_27 bl[27] br[27] bl_reset br_reset gnd discharge_6
Xmod_28 bl[28] br[28] bl_reset br_reset gnd discharge_6
Xmod_29 bl[29] br[29] bl_reset br_reset gnd discharge_6
Xmod_30 bl[30] br[30] bl_reset br_reset gnd discharge_6
Xmod_31 bl[31] br[31] bl_reset br_reset gnd discharge_6
Xmod_32 bl[32] br[32] bl_reset br_reset gnd discharge_6
Xmod_33 bl[33] br[33] bl_reset br_reset gnd discharge_6
Xmod_34 bl[34] br[34] bl_reset br_reset gnd discharge_6
Xmod_35 bl[35] br[35] bl_reset br_reset gnd discharge_6
Xmod_36 bl[36] br[36] bl_reset br_reset gnd discharge_6
Xmod_37 bl[37] br[37] bl_reset br_reset gnd discharge_6
Xmod_38 bl[38] br[38] bl_reset br_reset gnd discharge_6
Xmod_39 bl[39] br[39] bl_reset br_reset gnd discharge_6
Xmod_40 bl[40] br[40] bl_reset br_reset gnd discharge_6
Xmod_41 bl[41] br[41] bl_reset br_reset gnd discharge_6
Xmod_42 bl[42] br[42] bl_reset br_reset gnd discharge_6
Xmod_43 bl[43] br[43] bl_reset br_reset gnd discharge_6
Xmod_44 bl[44] br[44] bl_reset br_reset gnd discharge_6
Xmod_45 bl[45] br[45] bl_reset br_reset gnd discharge_6
Xmod_46 bl[46] br[46] bl_reset br_reset gnd discharge_6
Xmod_47 bl[47] br[47] bl_reset br_reset gnd discharge_6
Xmod_48 bl[48] br[48] bl_reset br_reset gnd discharge_6
Xmod_49 bl[49] br[49] bl_reset br_reset gnd discharge_6
Xmod_50 bl[50] br[50] bl_reset br_reset gnd discharge_6
Xmod_51 bl[51] br[51] bl_reset br_reset gnd discharge_6
Xmod_52 bl[52] br[52] bl_reset br_reset gnd discharge_6
Xmod_53 bl[53] br[53] bl_reset br_reset gnd discharge_6
Xmod_54 bl[54] br[54] bl_reset br_reset gnd discharge_6
Xmod_55 bl[55] br[55] bl_reset br_reset gnd discharge_6
Xmod_56 bl[56] br[56] bl_reset br_reset gnd discharge_6
Xmod_57 bl[57] br[57] bl_reset br_reset gnd discharge_6
Xmod_58 bl[58] br[58] bl_reset br_reset gnd discharge_6
Xmod_59 bl[59] br[59] bl_reset br_reset gnd discharge_6
Xmod_60 bl[60] br[60] bl_reset br_reset gnd discharge_6
Xmod_61 bl[61] br[61] bl_reset br_reset gnd discharge_6
Xmod_62 bl[62] br[62] bl_reset br_reset gnd discharge_6
Xmod_63 bl[63] br[63] bl_reset br_reset gnd discharge_6
.ENDS precharge_array

.SUBCKT pnand2_1 A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pnand2_1

.SUBCKT pnand3_1 A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pnand3_1

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.44 l=0.15 pd=3.1799999999999997 ps=3.1799999999999997 as=0.54 ad=0.54

.SUBCKT pnor2_1 A B Z vdd gnd
Xpmos1 vdd A net1 vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.44 l=0.15 pd=3.1799999999999997 ps=3.1799999999999997 as=0.54 ad=0.54
Xpmos2 net1 B Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.44 l=0.15 pd=3.1799999999999997 ps=3.1799999999999997 as=0.54 ad=0.54
Xnmos3 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
Xnmos4 Z B gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pnor2_1

.SUBCKT pinv_1 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1

.SUBCKT pnand2_1_hack A B Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos3 Z B net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
Xnmos4 net1 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.72 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pnand2_1_hack

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pinv_4 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.6 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.44 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_4

.SUBCKT buffer_stage_4_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_inv vdd gnd pinv_4
.ENDS buffer_stage_4_no_out_h_4

.SUBCKT logic_buffer_pnand2_4_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B out_inv vdd gnd pnand2_1_hack
Xbuffer out_inv out out_inv vdd gnd buffer_stage_4_no_out_h_4
.ENDS logic_buffer_pnand2_4_no_in_no_out_h_4

.SUBCKT pinv_1_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pinv_1_hack

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=3 w=4.5 l=0.15 pd=3.3 ps=3.3 as=0.5625 ad=0.5625

.SUBCKT pinv_5 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=4.5 l=0.15 pd=3.3 ps=3.3 as=0.5625 ad=0.5625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.7999999999999998 l=0.15 pd=1.5 ps=1.5 as=0.22499999999999998 ad=0.22499999999999998
.ENDS pinv_5

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=10 w=18.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pinv_20 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=10 w=18.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=10 w=7.199999999999999 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_20

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=32 w=58.56 l=0.15 pd=3.96 ps=3.96 as=0.68625 ad=0.68625

.SUBCKT pinv_65 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=32 w=58.56 l=0.15 pd=3.96 ps=3.96 as=0.68625 ad=0.68625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=32 w=23.36 l=0.15 pd=1.76 ps=1.76 as=0.27375 ad=0.27375
.ENDS pinv_65

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=15 w=27.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pinv_30 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=15 w=27.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=15 w=10.799999999999999 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_30

.SUBCKT buffer_stage_1_5_20_65_30_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_1_hack
Xinv1 out_1 out_2 vdd gnd pinv_5
Xinv2 out_2 out_3 vdd gnd pinv_20
Xinv3 out_3 out vdd gnd pinv_65
Xinv4 out out_inv vdd gnd pinv_30
.ENDS buffer_stage_1_5_20_65_30_no_out_h_4

.SUBCKT logic_buffer_pnand2_1_5_20_65_30_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnand2_1_hack
Xbuffer logic_out out out_inv vdd gnd buffer_stage_1_5_20_65_30_no_out_h_4
.ENDS logic_buffer_pnand2_1_5_20_65_30_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pnor2_1_hack A B Z vdd gnd
Xpmos1 vdd A net1 vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xpmos2 net1 B Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=1.8 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos3 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
Xnmos4 Z B gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.36 l=0.15 pd=1.02 ps=1.02 as=0.135 ad=0.135
.ENDS pnor2_1_hack

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.33 l=0.15 pd=3.63 ps=3.63 as=0.624375 ad=0.624375

.SUBCKT pinv_3__7 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.33 l=0.15 pd=3.63 ps=3.63 as=0.624375 ad=0.624375
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.33 l=0.15 pd=1.6300000000000001 ps=1.6300000000000001 as=0.249375 ad=0.249375
.ENDS pinv_3__7

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=12.25 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625

.SUBCKT pinv_13__6 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=12.25 l=0.15 pd=3.8 ps=3.8 as=0.65625 ad=0.65625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=4.9 l=0.15 pd=1.7000000000000002 ps=1.7000000000000002 as=0.2625 ad=0.2625
.ENDS pinv_13__6

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=25 w=45.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pinv_50 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=25 w=45.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=25 w=18.0 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_50

.SUBCKT buffer_stage_1_3__7_13__6_50_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_1_hack
Xinv1 out_1 out_2 vdd gnd pinv_3__7
Xinv2 out_2 out_inv vdd gnd pinv_13__6
Xinv3 out_inv out vdd gnd pinv_50
.ENDS buffer_stage_1_3__7_13__6_50_no_out_h_4

.SUBCKT logic_buffer_pnor2_1_3_7_13_6_50_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1_hack
Xbuffer logic_out out out_inv vdd gnd buffer_stage_1_3__7_13__6_50_no_out_h_4
.ENDS logic_buffer_pnor2_1_3_7_13_6_50_no_in_no_out_h_4

.SUBCKT pinv_5_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=3 w=4.5 l=0.15 pd=3.3 ps=3.3 as=0.5625 ad=0.5625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=3 w=1.7999999999999998 l=0.15 pd=1.5 ps=1.5 as=0.22499999999999998 ad=0.22499999999999998
.ENDS pinv_5_hack

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=13 w=22.49 l=0.15 pd=3.76 ps=3.76 as=0.6487499999999999 ad=0.6487499999999999

.SUBCKT pinv_25 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=13 w=22.49 l=0.15 pd=3.76 ps=3.76 as=0.6487499999999999 ad=0.6487499999999999
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=13 w=8.97 l=0.15 pd=1.6800000000000002 ps=1.6800000000000002 as=0.25875000000000004 ad=0.25875000000000004
.ENDS pinv_25

.SUBCKT pinv_50_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=25 w=45.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=25 w=18.0 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_50_hack

.SUBCKT pinv_65_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=32 w=58.56 l=0.15 pd=3.96 ps=3.96 as=0.68625 ad=0.68625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=32 w=23.36 l=0.15 pd=1.76 ps=1.76 as=0.27375 ad=0.27375
.ENDS pinv_65_hack

.SUBCKT buffer_stage_1_5_25_50_65_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_1_hack
Xinv1 out_1 out_2 vdd gnd pinv_5_hack
Xinv2 out_2 out_3 vdd gnd pinv_25
Xinv3 out_3 out vdd gnd pinv_50_hack
Xinv4 out out_inv vdd gnd pinv_65_hack
.ENDS buffer_stage_1_5_25_50_65_no_out_h_4

.SUBCKT logic_buffer_pnor2_1_5_25_50_65_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1_hack
Xbuffer logic_out out out_inv vdd gnd buffer_stage_1_5_25_50_65_no_out_h_4
.ENDS logic_buffer_pnor2_1_5_25_50_65_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.08 l=0.15 pd=3.38 ps=3.38 as=0.5775 ad=0.5775

.SUBCKT pinv_3__42 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.08 l=0.15 pd=3.38 ps=3.38 as=0.5775 ad=0.5775
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.23 l=0.15 pd=1.53 ps=1.53 as=0.230625 ad=0.230625
.ENDS pinv_3__42

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=6 w=10.530000000000001 l=0.15 pd=3.81 ps=3.81 as=0.6581250000000001 ad=0.6581250000000001

.SUBCKT pinv_11__7 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=6 w=10.530000000000001 l=0.15 pd=3.81 ps=3.81 as=0.6581250000000001 ad=0.6581250000000001
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=6 w=4.2 l=0.15 pd=1.7000000000000002 ps=1.7000000000000002 as=0.2625 ad=0.2625
.ENDS pinv_11__7

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=20 w=36.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675

.SUBCKT pinv_40 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=20 w=36.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=20 w=14.399999999999999 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_40

.SUBCKT buffer_stage_1_3__42_11__7_40_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_1_hack
Xinv1 out_1 out_2 vdd gnd pinv_3__42
Xinv2 out_2 out_inv vdd gnd pinv_11__7
Xinv3 out_inv out vdd gnd pinv_40
.ENDS buffer_stage_1_3__42_11__7_40_no_out_h_4

.SUBCKT logic_buffer_pnor2_1_3_42_11_7_40_no_in_no_out_h_4 A B out_inv out vdd gnd
Xlogic A B logic_out vdd gnd pnor2_1_hack
Xbuffer logic_out out out_inv vdd gnd buffer_stage_1_3__42_11__7_40_no_out_h_4
.ENDS logic_buffer_pnor2_1_3_42_11_7_40_no_in_no_out_h_4

.SUBCKT pnand3_1_hack A B C Z vdd gnd
Xpmos1 vdd A Z vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos2 Z B vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xpmos3 Z C vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos4 Z C net1 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos5 net1 B net2 gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
Xnmos6 net2 A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=1 w=0.9 l=0.15 pd=2.1 ps=2.1 as=0.3375 ad=0.3375
.ENDS pnand3_1_hack

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=2.79 l=0.15 pd=3.09 ps=3.09 as=0.5231250000000001 ad=0.5231250000000001

.SUBCKT pinv_3__1 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=2.79 l=0.15 pd=3.09 ps=3.09 as=0.5231250000000001 ad=0.5231250000000001
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.12 l=0.15 pd=1.4200000000000002 ps=1.4200000000000002 as=0.21000000000000002 ad=0.21000000000000002
.ENDS pinv_3__1

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=5 w=8.675 l=0.15 pd=3.77 ps=3.77 as=0.650625 ad=0.650625

.SUBCKT pinv_9__65 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=5 w=8.675 l=0.15 pd=3.77 ps=3.77 as=0.650625 ad=0.650625
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=5 w=3.4750000000000005 l=0.15 pd=1.6900000000000002 ps=1.6900000000000002 as=0.260625 ad=0.260625
.ENDS pinv_9__65

.SUBCKT pinv_30_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=15 w=27.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=15 w=10.799999999999999 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_30_hack

.SUBCKT buffer_stage_3__1_9__65_30_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_3__1
Xinv1 out_1 out vdd gnd pinv_9__65
Xinv2 out out_inv vdd gnd pinv_30_hack
.ENDS buffer_stage_3__1_9__65_30_no_out_h_4

.SUBCKT logic_buffer_pnand3_3_1_9_65_30_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1_hack
Xbuffer logic_out out out_inv vdd gnd buffer_stage_3__1_9__65_30_no_out_h_4
.ENDS logic_buffer_pnand3_3_1_9_65_30_no_in_no_out_h_4

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.21 l=0.15 pd=3.51 ps=3.51 as=0.6018749999999999 ad=0.6018749999999999

.SUBCKT pinv_3__56 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.21 l=0.15 pd=3.51 ps=3.51 as=0.6018749999999999 ad=0.6018749999999999
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.28 l=0.15 pd=1.58 ps=1.58 as=0.24 ad=0.24
.ENDS pinv_3__56

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=7 w=11.34 l=0.15 pd=3.54 ps=3.54 as=0.6075 ad=0.6075

.SUBCKT pinv_12__6 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=7 w=11.34 l=0.15 pd=3.54 ps=3.54 as=0.6075 ad=0.6075
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=7 w=4.55 l=0.15 pd=1.6 ps=1.6 as=0.24375000000000002 ad=0.24375000000000002
.ENDS pinv_12__6

* ptx X{0} {1} sky130_fd_pr__pfet_01v8 m=1 nf=22 w=40.480000000000004 l=0.15 pd=3.98 ps=3.98 as=0.6900000000000001 ad=0.6900000000000001

.SUBCKT pinv_45 A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=22 w=40.480000000000004 l=0.15 pd=3.98 ps=3.98 as=0.6900000000000001 ad=0.6900000000000001
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=22 w=16.169999999999998 l=0.15 pd=1.77 ps=1.77 as=0.275625 ad=0.275625
.ENDS pinv_45

.SUBCKT buffer_stage_3__56_12__6_45_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_3__56
Xinv1 out_1 out vdd gnd pinv_12__6
Xinv2 out out_inv vdd gnd pinv_45
.ENDS buffer_stage_3__56_12__6_45_no_out_h_4

.SUBCKT logic_buffer_pnand3_3_56_12_6_45_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1_hack
Xbuffer logic_out out out_inv vdd gnd buffer_stage_3__56_12__6_45_no_out_h_4
.ENDS logic_buffer_pnand3_3_56_12_6_45_no_in_no_out_h_4

.SUBCKT pinv_3__42_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=2 w=3.08 l=0.15 pd=3.38 ps=3.38 as=0.5775 ad=0.5775
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=2 w=1.23 l=0.15 pd=1.53 ps=1.53 as=0.230625 ad=0.230625
.ENDS pinv_3__42_hack

.SUBCKT pinv_11__7_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=6 w=10.530000000000001 l=0.15 pd=3.81 ps=3.81 as=0.6581250000000001 ad=0.6581250000000001
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=6 w=4.2 l=0.15 pd=1.7000000000000002 ps=1.7000000000000002 as=0.2625 ad=0.2625
.ENDS pinv_11__7_hack

.SUBCKT pinv_40_hack A Z vdd gnd
Xpmos1 Z A vdd vdd sky130_fd_pr__pfet_01v8 m=1 nf=20 w=36.0 l=0.15 pd=3.9 ps=3.9 as=0.675 ad=0.675
Xnmos2 Z A gnd gnd sky130_fd_pr__nfet_01v8 m=1 nf=20 w=14.399999999999999 l=0.15 pd=1.74 ps=1.74 as=0.27 ad=0.27
.ENDS pinv_40_hack

.SUBCKT buffer_stage_3__42_11__7_40_40_no_out_h_4 in out_inv out vdd gnd
Xinv0 in out_1 vdd gnd pinv_3__42_hack
Xinv1 out_1 out_2 vdd gnd pinv_11__7_hack
Xinv2 out_2 out_inv vdd gnd pinv_40_hack
Xinv3 out_inv out vdd gnd pinv_40_hack
.ENDS buffer_stage_3__42_11__7_40_40_no_out_h_4

.SUBCKT logic_buffer_pnand3_3_42_11_7_40_40_no_in_no_out_h_4 A B C out_inv out vdd gnd
Xlogic A B C logic_out vdd gnd pnand3_1_hack
Xbuffer logic_out out out_inv vdd gnd buffer_stage_3__42_11__7_40_40_no_out_h_4
.ENDS logic_buffer_pnand3_3_42_11_7_40_40_no_in_no_out_h_4

.SUBCKT control_buffers bank_sel read clk sense_trig decoder_clk clk_buf clk_bar wordline_en write_en write_en_bar sense_en tri_en tri_en_bar sample_en_bar bl_reset br_reset vdd gnd
Xdecoder_clk bank_sel clk decoder_clk_bar decoder_clk vdd gnd logic_buffer_pnand2_4_no_in_no_out_h_4
Xnor_read_clk read clk nor_read_clk vdd gnd pnor2_1
Xbr_reset nor_read_clk bank_sel_bar br_reset br_reset_bar vdd gnd logic_buffer_pnor2_1_3_42_11_7_40_no_in_no_out_h_4
Xclk_buf bank_sel clk clk_bar clk_buf vdd gnd logic_buffer_pnand2_1_5_20_65_30_no_in_no_out_h_4
Xwrite_buf read bank_sel_cbar write_en write_en_bar vdd gnd logic_buffer_pnor2_1_5_25_50_65_no_in_no_out_h_4
Xsense_amp_buf sample_bar_int sense_trig bank_sel sense_en_bar sense_en vdd gnd logic_buffer_pnand3_3_56_12_6_45_no_in_no_out_h_4
Xtri_en_buf sample_bar_int sense_trig bank_sel tri_en_bar tri_en vdd gnd logic_buffer_pnand3_3_42_11_7_40_40_no_in_no_out_h_4
Xsense_trig_bar sense_trig sense_trig_bar vdd gnd pinv_1
Xsample_bar_int bank_sel read sense_trig_bar sample_bar_int vdd gnd pnand3_1
Xsample_bar sample_bar_int sample_en_buf sample_en_bar vdd gnd buffer_stage_1_3__7_13__6_50_no_out_h_4
Xclk_bar clk clk_bar_int vdd gnd pinv_1
Xbank_sel_cbar bank_sel clk_bar_int bank_sel_cbar vdd gnd pnand2_1
Xwordline_buf sense_trig bank_sel_cbar wordline_en wordline_en_bar vdd gnd logic_buffer_pnor2_1_3_7_13_6_50_no_in_no_out_h_4
Xread_bar read read_bar vdd gnd pinv_1
Xbl_reset bank_sel clk read_bar bl_reset_bar bl_reset vdd gnd logic_buffer_pnand3_3_1_9_65_30_no_in_no_out_h_4
Xbank_sel_bar bank_sel bank_sel_bar vdd gnd pinv_1
.ENDS control_buffers

.SUBCKT flop_buffer_4_neg din clk dout vdd gnd
Xflop din flop_out flop_out_bar clk vdd gnd ms_flop_horz_pitch
Xbuffer flop_out dout dout_bar vdd gnd buffer_stage_4_no_out_no_nwell_cont_no_pwell_cont_h_3__2
.ENDS flop_buffer_4_neg

.SUBCKT flop_buffer_4 din clk dout vdd gnd
Xflop din flop_out flop_out_bar clk vdd gnd ms_flop_horz_pitch
Xbuffer flop_out_bar dout dout_bar vdd gnd buffer_stage_4_no_out_no_nwell_cont_no_pwell_cont_h_3__2
.ENDS flop_buffer_4

.SUBCKT bank DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] DATA[32] MASK[32] DATA[33] MASK[33] DATA[34] MASK[34] DATA[35] MASK[35] DATA[36] MASK[36] DATA[37] MASK[37] DATA[38] MASK[38] DATA[39] MASK[39] DATA[40] MASK[40] DATA[41] MASK[41] DATA[42] MASK[42] DATA[43] MASK[43] DATA[44] MASK[44] DATA[45] MASK[45] DATA[46] MASK[46] DATA[47] MASK[47] DATA[48] MASK[48] DATA[49] MASK[49] DATA[50] MASK[50] DATA[51] MASK[51] DATA[52] MASK[52] DATA[53] MASK[53] DATA[54] MASK[54] DATA[55] MASK[55] DATA[56] MASK[56] DATA[57] MASK[57] DATA[58] MASK[58] DATA[59] MASK[59] DATA[60] MASK[60] DATA[61] MASK[61] DATA[62] MASK[62] DATA[63] MASK[63] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] Csb read clk sense_trig decoder_clk vdd gnd vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] vdd_write vdd_wordline
Xcontrol_buffers bank_sel_buf read_buf clk sense_trig decoder_clk clk_buf clk_bar wordline_en write_en write_en_bar sense_en tri_en tri_en_bar sample_en_bar bl_reset br_reset vdd gnd control_buffers
Xtri_gate_array sense_out_bar[0] sense_out_bar[1] sense_out_bar[2] sense_out_bar[3] sense_out_bar[4] sense_out_bar[5] sense_out_bar[6] sense_out_bar[7] sense_out_bar[8] sense_out_bar[9] sense_out_bar[10] sense_out_bar[11] sense_out_bar[12] sense_out_bar[13] sense_out_bar[14] sense_out_bar[15] sense_out_bar[16] sense_out_bar[17] sense_out_bar[18] sense_out_bar[19] sense_out_bar[20] sense_out_bar[21] sense_out_bar[22] sense_out_bar[23] sense_out_bar[24] sense_out_bar[25] sense_out_bar[26] sense_out_bar[27] sense_out_bar[28] sense_out_bar[29] sense_out_bar[30] sense_out_bar[31] sense_out_bar[32] sense_out_bar[33] sense_out_bar[34] sense_out_bar[35] sense_out_bar[36] sense_out_bar[37] sense_out_bar[38] sense_out_bar[39] sense_out_bar[40] sense_out_bar[41] sense_out_bar[42] sense_out_bar[43] sense_out_bar[44] sense_out_bar[45] sense_out_bar[46] sense_out_bar[47] sense_out_bar[48] sense_out_bar[49] sense_out_bar[50] sense_out_bar[51] sense_out_bar[52] sense_out_bar[53] sense_out_bar[54] sense_out_bar[55] sense_out_bar[56] sense_out_bar[57] sense_out_bar[58] sense_out_bar[59] sense_out_bar[60] sense_out_bar[61] sense_out_bar[62] sense_out_bar[63] DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] tri_en tri_en_bar vdd gnd tri_gate_array
Xmask_in MASK[0] MASK[1] MASK[2] MASK[3] MASK[4] MASK[5] MASK[6] MASK[7] MASK[8] MASK[9] MASK[10] MASK[11] MASK[12] MASK[13] MASK[14] MASK[15] MASK[16] MASK[17] MASK[18] MASK[19] MASK[20] MASK[21] MASK[22] MASK[23] MASK[24] MASK[25] MASK[26] MASK[27] MASK[28] MASK[29] MASK[30] MASK[31] MASK[32] MASK[33] MASK[34] MASK[35] MASK[36] MASK[37] MASK[38] MASK[39] MASK[40] MASK[41] MASK[42] MASK[43] MASK[44] MASK[45] MASK[46] MASK[47] MASK[48] MASK[49] MASK[50] MASK[51] MASK[52] MASK[53] MASK[54] MASK[55] MASK[56] MASK[57] MASK[58] MASK[59] MASK[60] MASK[61] MASK[62] MASK[63] mask_in[0] mask_in_bar[0] mask_in[1] mask_in_bar[1] mask_in[2] mask_in_bar[2] mask_in[3] mask_in_bar[3] mask_in[4] mask_in_bar[4] mask_in[5] mask_in_bar[5] mask_in[6] mask_in_bar[6] mask_in[7] mask_in_bar[7] mask_in[8] mask_in_bar[8] mask_in[9] mask_in_bar[9] mask_in[10] mask_in_bar[10] mask_in[11] mask_in_bar[11] mask_in[12] mask_in_bar[12] mask_in[13] mask_in_bar[13] mask_in[14] mask_in_bar[14] mask_in[15] mask_in_bar[15] mask_in[16] mask_in_bar[16] mask_in[17] mask_in_bar[17] mask_in[18] mask_in_bar[18] mask_in[19] mask_in_bar[19] mask_in[20] mask_in_bar[20] mask_in[21] mask_in_bar[21] mask_in[22] mask_in_bar[22] mask_in[23] mask_in_bar[23] mask_in[24] mask_in_bar[24] mask_in[25] mask_in_bar[25] mask_in[26] mask_in_bar[26] mask_in[27] mask_in_bar[27] mask_in[28] mask_in_bar[28] mask_in[29] mask_in_bar[29] mask_in[30] mask_in_bar[30] mask_in[31] mask_in_bar[31] mask_in[32] mask_in_bar[32] mask_in[33] mask_in_bar[33] mask_in[34] mask_in_bar[34] mask_in[35] mask_in_bar[35] mask_in[36] mask_in_bar[36] mask_in[37] mask_in_bar[37] mask_in[38] mask_in_bar[38] mask_in[39] mask_in_bar[39] mask_in[40] mask_in_bar[40] mask_in[41] mask_in_bar[41] mask_in[42] mask_in_bar[42] mask_in[43] mask_in_bar[43] mask_in[44] mask_in_bar[44] mask_in[45] mask_in_bar[45] mask_in[46] mask_in_bar[46] mask_in[47] mask_in_bar[47] mask_in[48] mask_in_bar[48] mask_in[49] mask_in_bar[49] mask_in[50] mask_in_bar[50] mask_in[51] mask_in_bar[51] mask_in[52] mask_in_bar[52] mask_in[53] mask_in_bar[53] mask_in[54] mask_in_bar[54] mask_in[55] mask_in_bar[55] mask_in[56] mask_in_bar[56] mask_in[57] mask_in_bar[57] mask_in[58] mask_in_bar[58] mask_in[59] mask_in_bar[59] mask_in[60] mask_in_bar[60] mask_in[61] mask_in_bar[61] mask_in[62] mask_in_bar[62] mask_in[63] mask_in_bar[63] clk_buf vdd gnd flop_array_c64_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap
Xdata_in DATA[0] DATA[1] DATA[2] DATA[3] DATA[4] DATA[5] DATA[6] DATA[7] DATA[8] DATA[9] DATA[10] DATA[11] DATA[12] DATA[13] DATA[14] DATA[15] DATA[16] DATA[17] DATA[18] DATA[19] DATA[20] DATA[21] DATA[22] DATA[23] DATA[24] DATA[25] DATA[26] DATA[27] DATA[28] DATA[29] DATA[30] DATA[31] DATA[32] DATA[33] DATA[34] DATA[35] DATA[36] DATA[37] DATA[38] DATA[39] DATA[40] DATA[41] DATA[42] DATA[43] DATA[44] DATA[45] DATA[46] DATA[47] DATA[48] DATA[49] DATA[50] DATA[51] DATA[52] DATA[53] DATA[54] DATA[55] DATA[56] DATA[57] DATA[58] DATA[59] DATA[60] DATA[61] DATA[62] DATA[63] data_in[0] data_in_bar[0] data_in[1] data_in_bar[1] data_in[2] data_in_bar[2] data_in[3] data_in_bar[3] data_in[4] data_in_bar[4] data_in[5] data_in_bar[5] data_in[6] data_in_bar[6] data_in[7] data_in_bar[7] data_in[8] data_in_bar[8] data_in[9] data_in_bar[9] data_in[10] data_in_bar[10] data_in[11] data_in_bar[11] data_in[12] data_in_bar[12] data_in[13] data_in_bar[13] data_in[14] data_in_bar[14] data_in[15] data_in_bar[15] data_in[16] data_in_bar[16] data_in[17] data_in_bar[17] data_in[18] data_in_bar[18] data_in[19] data_in_bar[19] data_in[20] data_in_bar[20] data_in[21] data_in_bar[21] data_in[22] data_in_bar[22] data_in[23] data_in_bar[23] data_in[24] data_in_bar[24] data_in[25] data_in_bar[25] data_in[26] data_in_bar[26] data_in[27] data_in_bar[27] data_in[28] data_in_bar[28] data_in[29] data_in_bar[29] data_in[30] data_in_bar[30] data_in[31] data_in_bar[31] data_in[32] data_in_bar[32] data_in[33] data_in_bar[33] data_in[34] data_in_bar[34] data_in[35] data_in_bar[35] data_in[36] data_in_bar[36] data_in[37] data_in_bar[37] data_in[38] data_in_bar[38] data_in[39] data_in_bar[39] data_in[40] data_in_bar[40] data_in[41] data_in_bar[41] data_in[42] data_in_bar[42] data_in[43] data_in_bar[43] data_in[44] data_in_bar[44] data_in[45] data_in_bar[45] data_in[46] data_in_bar[46] data_in[47] data_in_bar[47] data_in[48] data_in_bar[48] data_in[49] data_in_bar[49] data_in[50] data_in_bar[50] data_in[51] data_in_bar[51] data_in[52] data_in_bar[52] data_in[53] data_in_bar[53] data_in[54] data_in_bar[54] data_in[55] data_in_bar[55] data_in[56] data_in_bar[56] data_in[57] data_in_bar[57] data_in[58] data_in_bar[58] data_in[59] data_in_bar[59] data_in[60] data_in_bar[60] data_in[61] data_in_bar[61] data_in[62] data_in_bar[62] data_in[63] data_in_bar[63] clk_bar vdd gnd flop_array_c64_w64_ms_flop_clk_buf_ms_flop_clk_buf_tap
Xwrite_driver_array data_in[0] data_in_bar[0] data_in[1] data_in_bar[1] data_in[2] data_in_bar[2] data_in[3] data_in_bar[3] data_in[4] data_in_bar[4] data_in[5] data_in_bar[5] data_in[6] data_in_bar[6] data_in[7] data_in_bar[7] data_in[8] data_in_bar[8] data_in[9] data_in_bar[9] data_in[10] data_in_bar[10] data_in[11] data_in_bar[11] data_in[12] data_in_bar[12] data_in[13] data_in_bar[13] data_in[14] data_in_bar[14] data_in[15] data_in_bar[15] data_in[16] data_in_bar[16] data_in[17] data_in_bar[17] data_in[18] data_in_bar[18] data_in[19] data_in_bar[19] data_in[20] data_in_bar[20] data_in[21] data_in_bar[21] data_in[22] data_in_bar[22] data_in[23] data_in_bar[23] data_in[24] data_in_bar[24] data_in[25] data_in_bar[25] data_in[26] data_in_bar[26] data_in[27] data_in_bar[27] data_in[28] data_in_bar[28] data_in[29] data_in_bar[29] data_in[30] data_in_bar[30] data_in[31] data_in_bar[31] data_in[32] data_in_bar[32] data_in[33] data_in_bar[33] data_in[34] data_in_bar[34] data_in[35] data_in_bar[35] data_in[36] data_in_bar[36] data_in[37] data_in_bar[37] data_in[38] data_in_bar[38] data_in[39] data_in_bar[39] data_in[40] data_in_bar[40] data_in[41] data_in_bar[41] data_in[42] data_in_bar[42] data_in[43] data_in_bar[43] data_in[44] data_in_bar[44] data_in[45] data_in_bar[45] data_in[46] data_in_bar[46] data_in[47] data_in_bar[47] data_in[48] data_in_bar[48] data_in[49] data_in_bar[49] data_in[50] data_in_bar[50] data_in[51] data_in_bar[51] data_in[52] data_in_bar[52] data_in[53] data_in_bar[53] data_in[54] data_in_bar[54] data_in[55] data_in_bar[55] data_in[56] data_in_bar[56] data_in[57] data_in_bar[57] data_in[58] data_in_bar[58] data_in[59] data_in_bar[59] data_in[60] data_in_bar[60] data_in[61] data_in_bar[61] data_in[62] data_in_bar[62] data_in[63] data_in_bar[63] bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] mask_in_bar[0] mask_in_bar[1] mask_in_bar[2] mask_in_bar[3] mask_in_bar[4] mask_in_bar[5] mask_in_bar[6] mask_in_bar[7] mask_in_bar[8] mask_in_bar[9] mask_in_bar[10] mask_in_bar[11] mask_in_bar[12] mask_in_bar[13] mask_in_bar[14] mask_in_bar[15] mask_in_bar[16] mask_in_bar[17] mask_in_bar[18] mask_in_bar[19] mask_in_bar[20] mask_in_bar[21] mask_in_bar[22] mask_in_bar[23] mask_in_bar[24] mask_in_bar[25] mask_in_bar[26] mask_in_bar[27] mask_in_bar[28] mask_in_bar[29] mask_in_bar[30] mask_in_bar[31] mask_in_bar[32] mask_in_bar[33] mask_in_bar[34] mask_in_bar[35] mask_in_bar[36] mask_in_bar[37] mask_in_bar[38] mask_in_bar[39] mask_in_bar[40] mask_in_bar[41] mask_in_bar[42] mask_in_bar[43] mask_in_bar[44] mask_in_bar[45] mask_in_bar[46] mask_in_bar[47] mask_in_bar[48] mask_in_bar[49] mask_in_bar[50] mask_in_bar[51] mask_in_bar[52] mask_in_bar[53] mask_in_bar[54] mask_in_bar[55] mask_in_bar[56] mask_in_bar[57] mask_in_bar[58] mask_in_bar[59] mask_in_bar[60] mask_in_bar[61] mask_in_bar[62] mask_in_bar[63] write_en write_en_bar vdd_write gnd write_driver_array
Xsense_amp_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] bl[32] bl[33] bl[34] bl[35] bl[36] bl[37] bl[38] bl[39] bl[40] bl[41] bl[42] bl[43] bl[44] bl[45] bl[46] bl[47] bl[48] bl[49] bl[50] bl[51] bl[52] bl[53] bl[54] bl[55] bl[56] bl[57] bl[58] bl[59] bl[60] bl[61] bl[62] bl[63] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] br[32] br[33] br[34] br[35] br[36] br[37] br[38] br[39] br[40] br[41] br[42] br[43] br[44] br[45] br[46] br[47] br[48] br[49] br[50] br[51] br[52] br[53] br[54] br[55] br[56] br[57] br[58] br[59] br[60] br[61] br[62] br[63] sense_out[0] sense_out[1] sense_out[2] sense_out[3] sense_out[4] sense_out[5] sense_out[6] sense_out[7] sense_out[8] sense_out[9] sense_out[10] sense_out[11] sense_out[12] sense_out[13] sense_out[14] sense_out[15] sense_out[16] sense_out[17] sense_out[18] sense_out[19] sense_out[20] sense_out[21] sense_out[22] sense_out[23] sense_out[24] sense_out[25] sense_out[26] sense_out[27] sense_out[28] sense_out[29] sense_out[30] sense_out[31] sense_out[32] sense_out[33] sense_out[34] sense_out[35] sense_out[36] sense_out[37] sense_out[38] sense_out[39] sense_out[40] sense_out[41] sense_out[42] sense_out[43] sense_out[44] sense_out[45] sense_out[46] sense_out[47] sense_out[48] sense_out[49] sense_out[50] sense_out[51] sense_out[52] sense_out[53] sense_out[54] sense_out[55] sense_out[56] sense_out[57] sense_out[58] sense_out[59] sense_out[60] sense_out[61] sense_out[62] sense_out[63] sense_out_bar[0] sense_out_bar[1] sense_out_bar[2] sense_out_bar[3] sense_out_bar[4] sense_out_bar[5] sense_out_bar[6] sense_out_bar[7] sense_out_bar[8] sense_out_bar[9] sense_out_bar[10] sense_out_bar[11] sense_out_bar[12] sense_out_bar[13] sense_out_bar[14] sense_out_bar[15] sense_out_bar[16] sense_out_bar[17] sense_out_bar[18] sense_out_bar[19] sense_out_bar[20] sense_out_bar[21] sense_out_bar[22] sense_out_bar[23] sense_out_bar[24] sense_out_bar[25] sense_out_bar[26] sense_out_bar[27] sense_out_bar[28] sense_out_bar[29] sense_out_bar[30] sense_out_bar[31] sense_out_bar[32] sense_out_bar[33] sense_out_bar[34] sense_out_bar[35] sense_out_bar[36] sense_out_bar[37] sense_out_bar[38] sense_out_bar[39] sense_out_bar[40] sense_out_bar[41] sense_out_bar[42] sense_out_bar[43] sense_out_bar[44] sense_out_bar[45] sense_out_bar[46] sense_out_bar[47] sense_out_bar[48] sense_out_bar[49] sense_out_bar[50] sense_out_bar[51] sense_out_bar[52] sense_out_bar[53] sense_out_bar[54] sense_out_bar[55] sense_out_bar[56] sense_out_bar[57] sense_out_bar[58] sense_out_bar[59] sense_out_bar[60] sense_out_bar[61] sense_out_bar[62] sense_out_bar[63] sense_en gnd sample_en_bar vclamp vclampp vdd vref sense_amp_array
Xprecharge_array bl[0] bl[1] bl[2] bl[3] bl[4] bl[5] bl[6] bl[7] bl[8] bl[9] bl[10] bl[11] bl[12] bl[13] bl[14] bl[15] bl[16] bl[17] bl[18] bl[19] bl[20] bl[21] bl[22] bl[23] bl[24] bl[25] bl[26] bl[27] bl[28] bl[29] bl[30] bl[31] bl[32] bl[33] bl[34] bl[35] bl[36] bl[37] bl[38] bl[39] bl[40] bl[41] bl[42] bl[43] bl[44] bl[45] bl[46] bl[47] bl[48] bl[49] bl[50] bl[51] bl[52] bl[53] bl[54] bl[55] bl[56] bl[57] bl[58] bl[59] bl[60] bl[61] bl[62] bl[63] br[0] br[1] br[2] br[3] br[4] br[5] br[6] br[7] br[8] br[9] br[10] br[11] br[12] br[13] br[14] br[15] br[16] br[17] br[18] br[19] br[20] br[21] br[22] br[23] br[24] br[25] br[26] br[27] br[28] br[29] br[30] br[31] br[32] br[33] br[34] br[35] br[36] br[37] br[38] br[39] br[40] br[41] br[42] br[43] br[44] br[45] br[46] br[47] br[48] br[49] br[50] br[51] br[52] br[53] br[54] br[55] br[56] br[57] br[58] br[59] br[60] br[61] br[62] br[63] bl_reset br_reset gnd precharge_array
Xbitcell_array bl[0] br[0] bl[1] br[1] bl[2] br[2] bl[3] br[3] bl[4] br[4] bl[5] br[5] bl[6] br[6] bl[7] br[7] bl[8] br[8] bl[9] br[9] bl[10] br[10] bl[11] br[11] bl[12] br[12] bl[13] br[13] bl[14] br[14] bl[15] br[15] bl[16] br[16] bl[17] br[17] bl[18] br[18] bl[19] br[19] bl[20] br[20] bl[21] br[21] bl[22] br[22] bl[23] br[23] bl[24] br[24] bl[25] br[25] bl[26] br[26] bl[27] br[27] bl[28] br[28] bl[29] br[29] bl[30] br[30] bl[31] br[31] bl[32] br[32] bl[33] br[33] bl[34] br[34] bl[35] br[35] bl[36] br[36] bl[37] br[37] bl[38] br[38] bl[39] br[39] bl[40] br[40] bl[41] br[41] bl[42] br[42] bl[43] br[43] bl[44] br[44] bl[45] br[45] bl[46] br[46] bl[47] br[47] bl[48] br[48] bl[49] br[49] bl[50] br[50] bl[51] br[51] bl[52] br[52] bl[53] br[53] bl[54] br[54] bl[55] br[55] bl[56] br[56] bl[57] br[57] bl[58] br[58] bl[59] br[59] bl[60] br[60] bl[61] br[61] bl[62] br[62] bl[63] br[63] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] vdd gnd bitcell_array
Xwordline_driver dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] wl[0] wl[1] wl[2] wl[3] wl[4] wl[5] wl[6] wl[7] wl[8] wl[9] wl[10] wl[11] wl[12] wl[13] wl[14] wl[15] wl[16] wl[17] wl[18] wl[19] wl[20] wl[21] wl[22] wl[23] wl[24] wl[25] wl[26] wl[27] wl[28] wl[29] wl[30] wl[31] wordline_en vdd_wordline gnd wordline_driver_array
Xbank_sel_buf Csb clk bank_sel_buf vdd gnd flop_buffer_4_neg
Xread_buf read clk read_buf vdd gnd flop_buffer_4
.ENDS bank

.SUBCKT sram1 DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] DATA[32] MASK[32] DATA[33] MASK[33] DATA[34] MASK[34] DATA[35] MASK[35] DATA[36] MASK[36] DATA[37] MASK[37] DATA[38] MASK[38] DATA[39] MASK[39] DATA[40] MASK[40] DATA[41] MASK[41] DATA[42] MASK[42] DATA[43] MASK[43] DATA[44] MASK[44] DATA[45] MASK[45] DATA[46] MASK[46] DATA[47] MASK[47] DATA[48] MASK[48] DATA[49] MASK[49] DATA[50] MASK[50] DATA[51] MASK[51] DATA[52] MASK[52] DATA[53] MASK[53] DATA[54] MASK[54] DATA[55] MASK[55] DATA[56] MASK[56] DATA[57] MASK[57] DATA[58] MASK[58] DATA[59] MASK[59] DATA[60] MASK[60] DATA[61] MASK[61] DATA[62] MASK[62] DATA[63] MASK[63] Csb Web clk sense_trig vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] vdd_write vdd_wordline ADDR[0] ADDR[1] ADDR[2] ADDR[3] ADDR[4] clk vdd gnd
Xbank0 DATA[0] MASK[0] DATA[1] MASK[1] DATA[2] MASK[2] DATA[3] MASK[3] DATA[4] MASK[4] DATA[5] MASK[5] DATA[6] MASK[6] DATA[7] MASK[7] DATA[8] MASK[8] DATA[9] MASK[9] DATA[10] MASK[10] DATA[11] MASK[11] DATA[12] MASK[12] DATA[13] MASK[13] DATA[14] MASK[14] DATA[15] MASK[15] DATA[16] MASK[16] DATA[17] MASK[17] DATA[18] MASK[18] DATA[19] MASK[19] DATA[20] MASK[20] DATA[21] MASK[21] DATA[22] MASK[22] DATA[23] MASK[23] DATA[24] MASK[24] DATA[25] MASK[25] DATA[26] MASK[26] DATA[27] MASK[27] DATA[28] MASK[28] DATA[29] MASK[29] DATA[30] MASK[30] DATA[31] MASK[31] DATA[32] MASK[32] DATA[33] MASK[33] DATA[34] MASK[34] DATA[35] MASK[35] DATA[36] MASK[36] DATA[37] MASK[37] DATA[38] MASK[38] DATA[39] MASK[39] DATA[40] MASK[40] DATA[41] MASK[41] DATA[42] MASK[42] DATA[43] MASK[43] DATA[44] MASK[44] DATA[45] MASK[45] DATA[46] MASK[46] DATA[47] MASK[47] DATA[48] MASK[48] DATA[49] MASK[49] DATA[50] MASK[50] DATA[51] MASK[51] DATA[52] MASK[52] DATA[53] MASK[53] DATA[54] MASK[54] DATA[55] MASK[55] DATA[56] MASK[56] DATA[57] MASK[57] DATA[58] MASK[58] DATA[59] MASK[59] DATA[60] MASK[60] DATA[61] MASK[61] DATA[62] MASK[62] DATA[63] MASK[63] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] Csb Web clk sense_trig decoder_clk vdd gnd vref vclamp vclampp DATA_OUT[0] DATA_OUT[1] DATA_OUT[2] DATA_OUT[3] DATA_OUT[4] DATA_OUT[5] DATA_OUT[6] DATA_OUT[7] DATA_OUT[8] DATA_OUT[9] DATA_OUT[10] DATA_OUT[11] DATA_OUT[12] DATA_OUT[13] DATA_OUT[14] DATA_OUT[15] DATA_OUT[16] DATA_OUT[17] DATA_OUT[18] DATA_OUT[19] DATA_OUT[20] DATA_OUT[21] DATA_OUT[22] DATA_OUT[23] DATA_OUT[24] DATA_OUT[25] DATA_OUT[26] DATA_OUT[27] DATA_OUT[28] DATA_OUT[29] DATA_OUT[30] DATA_OUT[31] DATA_OUT[32] DATA_OUT[33] DATA_OUT[34] DATA_OUT[35] DATA_OUT[36] DATA_OUT[37] DATA_OUT[38] DATA_OUT[39] DATA_OUT[40] DATA_OUT[41] DATA_OUT[42] DATA_OUT[43] DATA_OUT[44] DATA_OUT[45] DATA_OUT[46] DATA_OUT[47] DATA_OUT[48] DATA_OUT[49] DATA_OUT[50] DATA_OUT[51] DATA_OUT[52] DATA_OUT[53] DATA_OUT[54] DATA_OUT[55] DATA_OUT[56] DATA_OUT[57] DATA_OUT[58] DATA_OUT[59] DATA_OUT[60] DATA_OUT[61] DATA_OUT[62] DATA_OUT[63] vdd_write vdd_wordline bank
Xrow_decoder ADDR[0] ADDR[1] ADDR[2] ADDR[3] ADDR[4] dec_out[0] dec_out[1] dec_out[2] dec_out[3] dec_out[4] dec_out[5] dec_out[6] dec_out[7] dec_out[8] dec_out[9] dec_out[10] dec_out[11] dec_out[12] dec_out[13] dec_out[14] dec_out[15] dec_out[16] dec_out[17] dec_out[18] dec_out[19] dec_out[20] dec_out[21] dec_out[22] dec_out[23] dec_out[24] dec_out[25] dec_out[26] dec_out[27] dec_out[28] dec_out[29] dec_out[30] dec_out[31] decoder_clk vdd gnd hierarchical_decoder_32rows
.ENDS sram1
